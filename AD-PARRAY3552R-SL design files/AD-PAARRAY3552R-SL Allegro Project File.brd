# Allegro board AD-PAARRAY3552R-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VD1: length 12.3
  TOP w0.254: R150.2 36.53,10.36 36.22,10.67 32.89,10.67 32.82,10.74 U31.1
  TOP w1.016: VD1.1 36.53,3.61 R150.2
VD2: length 14.8
  TOP w0.254: R152.1 24.69,10.36 24.99,10.67 28.32,10.67 28.4,10.74 U31.16
  TOP w1.016: R152.1 24.69,4.32 26.09,2.92 VD2.1
VG1: length 6.4
  BOTTOM w0.305: U28.1 14.32,63.17 13.93,63.56 C197.1 11.53,65.94 VG1.1
VG2: length 9.1
  BOTTOM w0.305: VG2.1 19.15,65.94 C198.1 20.8,65.19 20.8,63.3 21.29,62.81 23.57,62.81 23.77,62.62 U29.1
VGC1: length 6.9
  BOTTOM w0.305: U18.1 30.93,62.92 29.17,64.68 C207.1 26.77,65.94 VGC1.1
VGC2: length 8.5
  BOTTOM w0.305: VGC2.1 42.01,65.94 C54.1 44.41,64.7 45.43,63.69 47.09,63.69 47.54,63.24 U14.1
VGP1: length 9.1
  BOTTOM w0.305: VGP1.1 34.39,65.94 C208.1 36.79,64.68 37.31,64.16 37.31,63.3 37.77,62.84 40.13,62.84 40.38,62.59 U19.1
VGP2: length 10.1
  BOTTOM w0.305: U15.1 56.99,63.02 56.32,63.69 53.94,63.69 53.29,64.34 52.55,64.34 52.03,64.86 C60.1 49.63,65.94 VGP2.1
VREGO_A: length 17.9
  TOP w0.203: U20.L3 v2(34.03,33.25) ; v2(30.46,27.27) U20.B9 v2(29.81,27.27) U20.C9 v2(30.46,27.27) ; v2(30.46,27.27) U20.C8 ; v2(28.51,33.12) U20.L11 v2(29.16,32.47) U20.K10
  L4_PWR w0.305: 27.03,31.64 v2(28.51,33.12) v2(29.16,32.47) 29.42,32.47 31.22,34.26 33.43,34.26 34.03,33.66 v2(34.03,33.25)
  BOTTOM w0.305: C137.1 C209.2 30.66,26.69 30.66,27.06 v2(30.46,27.27) v2(29.81,27.27) ; v2(29.16,32.47) v2(28.51,33.12)
  BOTTOM w0.381: v2(28.51,33.12) 28.12,33.5 C140.1
VREGO_B: length 27.7
  TOP w0.203: U20.J1 v2(35.66,31.82) ; U20.D11 v2(28.51,28.57) ; U20.L7 v2(31.43,33.25)
  TOP w0.33: U20.A9 30.13,25.99 29.08,24.94 v1(29.08,24.82)
  TOP w0.381: C210.2 28.6,24.33 v1(29.08,24.82)
  L4_PWR w0.305: v2(35.66,31.82) 36.2,32.36 36.2,32.64 35.86,32.97 35.33,32.97 35.13,32.77 33.66,32.77 33.48,32.94 33.48,33.43 33.15,33.76 31.62,33.76 31.43,33.56 v2(31.43,33.25) 31.43,32.25 31.6,32.08 31.6,30.98 31.35,30.73 29.01,30.73 28.78,30.96 28.35,30.96 27.99,30.61 27.99,29.08 v2(28.51,28.57) 27.58,27.64 27.58,25.88 28.65,24.82 v1(29.08,24.82)
  BOTTOM w0.305: C133.1 27.84,27.98 27.98,27.98 28.51,28.51 v2(28.51,28.57) ; v2(31.43,33.25) 31.65,33.47 C132.1
  BOTTOM w0.381: v2(35.66,31.82) 36.22,31.82 C130.1
VREGO_C: length 25
  TOP w0.203: U20.D10 v2(29.16,28.57) ; U20.K1 v2(35.66,32.47) ; U20.L6 v2(32.08,33.25)
  TOP w0.33: U20.A8 30.78,25.88 29.9,24.99 v1(29.9,24.82)
  TOP w0.381: v1(29.9,24.82) 29.9,23.84 C211.2
  L4_PWR w0.305: v2(35.66,32.47) 35.45,32.26 33.07,32.26 v2(32.08,33.25) 32.08,30.73 31.62,30.28 28.91,30.28 28.73,30.1 28.73,28.99 v2(29.16,28.57) 29.16,28.55 28.07,27.46 28.07,26.11 28.68,25.5 29.39,25.5 29.9,24.99 v1(29.9,24.82)
  BOTTOM w0.305: C127.1 28.71,29.01 v2(29.16,28.57) ; C126.1 32.66,33.78 32.13,33.25 v2(32.08,33.25)
  BOTTOM w0.381: C125.1 36.13,32.94 v2(35.66,32.47)
VREGO_D: length 5.6
  TOP w0.203: U20.A6 v2(32.41,25.97) U20.A5 ; U20.B8 v2(31.11,27.27)
  BOTTOM w0.305: v2(31.11,27.27) 31.11,27.26 C212.2 31.75,26.62 v2(32.41,25.97)
  BOTTOM w0.508: v2(32.41,25.97) 32.68,25.69 C134.2 C131.2
VRXOUT: length 13.4
  TOP w0.203: U20.A3 v2(34.36,26.62) ; U20.D1 v2(35.66,27.92) ; U20.D1 v2(35.01,27.92) U20.D2 v2(34.36,27.92) U20.D3 ; U20.D1 v2(35.66,28.57) U20.E1 ; U20.B5 v2(33.06,26.62)
  BOTTOM w0.305: v2(33.06,26.62) 33.37,26.62 C142.2 34.04,26.62 v2(34.36,26.62) 34.52,26.45 34.52,25.76 34.77,25.5 36.12,25.5 36.37,25.76 36.37,27.1 36.17,27.3 35.67,27.3 C138.1 35.66,27.3 v2(35.66,27.92) ; v2(35.66,27.92) v2(35.01,27.92) v2(34.36,27.92) ; v2(35.66,27.92) v2(35.66,28.57)
VTXOUT: length 4.1
  TOP w0.203: U20.C3 v2(34.36,27.27) ; U20.B6 v2(32.41,26.62)
  L4_PWR w0.305: v2(34.36,27.27) 32.73,27.27 32.41,26.94 v2(32.41,26.62)
  BOTTOM w0.305: v2(32.41,26.62) 32.41,26.94 C141.2

## Copper pours and planes (outline as drawn)
1V8 on L4_PWR (solid shape): outline of 1976 points within 4.85,23.3 55.93,65.28
1V8 on TOP: 39.67,24.59 39.75,24.56 39.78,24.49 39.78,23.03 39.75,22.95 39.67,22.92 39.33,22.92 39.08,22.82 38.97,22.57 38.98,22.52 38.99,22.47 38.99,22.17 38.98,22.12 38.97,22.07 38.98,22.02 38.99,21.97 38.99,21.67 38.98,21.64 38.97,21.6 38.91,21.47 38.77,21.41 38.51,21.41 37.74,22.17 37.74,24.43 37.9,24.59
3V3 on BOTTOM (solid shape): 27.84,27 27.84,24.56 28.04,24.36 30,24.36 30.12,24.23 30.12,23.22 24.71,23.22 24.54,23.39 24.54,24.23 24.83,24.52 26.28,24.52 26.85,25.1 26.85,26.57 27.69,27.41 28.24,27.41
3V3 on L4_PWR (solid shape): 29.69,33.4 29.24,32.94 29.11,32.94 28.3,33.76 28.3,34.04 28.52,34.26 29.69,34.26
3V3 on TOP: 48.84,24.59 48.92,24.56 48.95,24.49 48.95,23.03 48.92,22.96 48.85,22.92 48.5,22.92 48.25,22.82 48.14,22.57 48.15,22.52 48.16,22.46 48.16,22.17 48.15,22.11 48.14,22.07 48.15,22.02 48.16,21.96 48.16,21.67 48.14,21.6 48.08,21.47 47.94,21.41 47.68,21.41 46.91,22.17 46.91,24.43 47.07,24.59
3V3 on L4_PWR: outline of 192 points within 4.14,3.23 76.66,43.13
5V0 on BOTTOM (solid shape): 9.04,58.75 9.04,57.81 8.81,57.58 7.87,57.58 7.7,57.76 7.7,58.06 8.59,58.95 8.84,58.95
5V0 on L3_SIG (solid shape): 18.11,41.86 18.11,41.61 16.89,41.61 16.56,41.94 16.56,42.19 16.94,42.57 16.94,43.03
5V0 on L4_PWR (solid shape): outline of 977 points within 8.48,51.79 59.64,58.98
5V0 on BOTTOM: 59.46,57.61 58.8,57.61 58.67,57.48 58.67,54.91 58.85,54.74 59.56,54.74 59.59,54.76 59.59,57.48
5V0_5611 on TOP (solid shape): 64.11,62.89 64.18,62.86 64.21,62.79 64.21,61.62 65.15,60.69 65.15,60.55 65.15,60.51 65.17,60.46 65.18,60.44 65.18,60 65.18,59.99 65.18,59.63 65.15,59.55 65.07,59.52 64.38,59.52 64.24,59.46 64.18,59.32 64.18,58.57 64.15,58.5 64.07,58.47 62.89,58.47 62.82,58.5 62.79,58.57 62.79,62.79 62.82,62.86 62.89,62.89
5V0_6201U on TOP: 9.53,21.92 9.58,21.92 9.63,21.95 10.07,21.95 10.09,21.95 10.45,21.95 10.53,21.92 10.55,21.84 10.55,21.15 10.61,21 10.76,20.95 11.51,20.95 11.58,20.92 11.61,20.84 11.61,19.66 11.58,19.59 11.51,19.56 7.29,19.56 7.22,19.59 7.19,19.66 7.19,20.88 7.22,20.95 7.29,20.98 8.46,20.98 9.39,21.92
5V0_G140 on TOP (solid shape): 9.37,16.59 9.37,12.06 5.97,12.06 5.97,16.61 6.1,16.74 9.22,16.74
5V0_G140 on TOP (solid shape): 21.21,16.59 21.21,12.06 17.81,12.06 17.81,16.61 17.93,16.74 21.06,16.74
5V0_G140 on TOP (solid shape): 17.12,18.31 17.12,17.45 13.41,17.45 13.26,17.6 13.26,18.31 13.41,18.47 16.97,18.47
5V0_G140 on BOTTOM (solid shape): 8.69,16.46 8.69,15.49 8.31,15.11 8.31,12.95 8.28,12.93 5.64,12.93 5.61,12.95 5.61,16.54 5.77,16.69 8.46,16.69
5V0_G140 on BOTTOM (solid shape): 21.56,16.54 21.56,12.95 21.54,12.93 18.9,12.93 18.87,12.95 18.87,15.11 18.49,15.49 18.49,16.46 18.72,16.69 21.41,16.69
5V0_G140 on L3_SIG (solid shape): 15.95,17.96 15.95,16.76 13.26,16.76 13.26,17.91 13.46,18.11 15.8,18.11
5V0_G140 on L3_SIG (solid shape): 20.85,16.66 20.85,15.65 20.6,15.39 6.65,15.39 6.32,15.72 6.32,16.66 6.65,16.99 20.52,16.99
5V0_G140 on TOP: 18.95,18.75 18.98,18.82 19.05,18.85 20.51,18.85 20.58,18.82 20.61,18.75 20.61,18.4 20.72,18.15 20.97,18.04 21.01,18.05 21.07,18.06 21.36,18.06 21.42,18.05 21.47,18.04 21.51,18.05 21.57,18.06 21.86,18.06 21.94,18.05 22.07,17.98 22.12,17.84 22.12,17.58 21.21,16.66 21.21,16.23 21.16,16.18 17.86,16.18 17.81,16.23 17.81,17.78 18.01,17.98 18.82,17.98 18.95,18.11
5V6 on TOP (solid shape): 66.5,45.14 66.5,41.45 68.53,39.42 68.53,34.34 64.85,34.34 63.3,35.89 63.3,45.14 63.42,45.26 66.37,45.26
5V6 on BOTTOM (solid shape): 64.59,45.01 64.59,44.5 65.1,43.99 65.1,43.74 64.34,42.98 63.58,42.98 63.32,43.23 63.32,45.01 63.58,45.26 64.34,45.26
5V6 on L3_SIG (solid shape): outline of 285 points within 43.69,37.74 65.84,54.2
5V6 on TOP: 15.27,19.56 15.27,21.95 15.29,21.97 16.92,21.97 17.27,21.62 17.27,19.69 17.14,19.56
5V6 on TOP: 52.27,20.8 52.25,20.86 52.25,20.92 52.27,20.95 52.28,20.99 52.29,21.04 52.32,21.11 52.39,21.13 52.59,21.13 52.67,21.12 52.73,21.11 53.05,21.25 53.19,21.57 53.08,21.86 52.81,22.02 52.73,22.03 52.59,22.01 52.47,21.94 52.44,21.92 52.39,21.92 52.32,21.96 52.29,22.03 52.29,22.11 52.27,22.17 52.27,22.46 52.29,22.52 52.29,22.57 52.18,22.82 51.93,22.92 51.55,22.92 51.46,23.01 51.46,24.54 51.48,24.57 51.51,24.59 53.37,24.59 53.54,24.41 53.54,20.95 53.34,20.75 52.32,20.75
5V6 on TOP: 42.98,42.75 55.45,42.75 55.48,42.73 55.5,42.7 55.5,40.84 55.48,40.81 55.45,40.79 50.22,40.79 50,40.58 50,37.4 49.58,36.98 49.43,36.82 49.38,36.6 49.38,36.54 49.39,36.42 49.36,36.34 49.28,36.32 49.17,36.32 49.09,36.34 49.06,36.42 49.07,36.54 49.07,36.6 49.02,36.82 48.87,36.98 48.45,37.4 48.45,40.58 48.23,40.79 43,40.79 42.97,40.81 42.95,40.84 42.95,42.72
5V6 on TOP: 44.37,24.41 44.37,20.95 44.17,20.75 43.15,20.75 43.08,20.83 43.06,20.86 43.07,20.89 43.11,20.98 43.12,21.07 43.12,21.13 43.42,21.13 43.49,21.12 43.56,21.11 44.02,21.57 43.56,22.03 43.42,22 43.29,21.93 43.27,21.92 43.22,21.92 43.14,21.96 43.12,22.04 43.12,22.07 43.12,22.12 43.1,22.17 43.1,22.47 43.12,22.52 43.12,22.57 43.01,22.82 42.76,22.92 42.38,22.92 42.29,23.01 42.29,24.54 42.31,24.57 42.34,24.59 44.2,24.59
5V6 on TOP: 21.51,22.63 21.53,22.49 21.59,22.37 21.61,22.34 21.61,22.29 21.58,22.22 21.5,22.19 21.42,22.19 21.36,22.17 21.07,22.17 21.01,22.19 20.97,22.19 20.72,22.09 20.61,21.83 20.61,21.45 20.52,21.36 19,21.36 18.96,21.38 18.95,21.41 18.95,23.27 19.13,23.44 21.23,23.44 21.51,23.17
5V6 on BOTTOM: 59.54,51.94 58.75,51.94 58.74,51.93 58.51,51.93 58.27,51.69 58.27,48.51 58.37,48.41 59.33,48.41 59.59,48.67 59.59,51.89
5V6 on L4_PWR: outline of 85 points within 15.98,16.81 67.28,45.72
48V0_7000_2 on TOP (solid shape): 86.44,31.62 86.44,30.4 85.9,29.87 78.79,29.87 78.28,30.38 78.28,31.9 86.16,31.9
48V0_7000_2 on TOP (solid shape): 81.05,51.33 81.05,48.84 80.52,48.31 74.88,48.31 74.75,48.44 74.75,49.58 75.56,50.39 77.19,50.39 77.37,50.57 77.37,51.49 77.75,51.87 80.52,51.87
48V0_7000_2 on L4_PWR (solid shape): outline of 203 points within 78.18,30.07 83.92,51.66
48V0_G140 on TOP (solid shape): 43.41,16.59 43.41,12.06 40,12.06 40,16.61 40.13,16.74 43.26,16.74
48V0_G140 on TOP (solid shape): 55.24,16.59 55.24,12.06 51.84,12.06 51.84,16.61 51.97,16.74 55.09,16.74
48V0_G140 on TOP (solid shape): 51.16,18.31 51.16,17.45 47.45,17.45 47.29,17.6 47.29,18.31 47.45,18.47 51,18.47
48V0_G140 on TOP (solid shape): 86.44,10.03 86.44,8.81 85.9,8.28 78.79,8.28 78.28,8.79 78.28,10.31 86.16,10.31
48V0_G140 on BOTTOM (solid shape): 42.72,16.46 42.72,15.49 42.34,15.11 42.34,12.95 42.32,12.93 39.67,12.93 39.65,12.95 39.65,16.54 39.8,16.69 42.49,16.69
48V0_G140 on BOTTOM (solid shape): 55.6,16.54 55.6,12.95 55.58,12.93 52.93,12.93 52.91,12.95 52.91,15.11 52.53,15.49 52.53,16.46 52.76,16.69 55.45,16.69
48V0_G140 on L3_SIG (solid shape): 49.99,17.96 49.99,16.76 47.29,16.76 47.29,17.91 47.5,18.11 49.83,18.11
48V0_G140 on L3_SIG (solid shape): 54.89,16.66 54.89,14.88 54.66,14.66 54.33,14.66 53.59,15.39 40.69,15.39 40.36,15.72 40.36,16.66 40.69,16.99 54.56,16.99
48V0_GTRB on TOP (solid shape): 26.39,16.59 26.39,12.06 22.99,12.06 22.99,16.61 23.11,16.74 26.24,16.74
48V0_GTRB on TOP (solid shape): 38.23,16.59 38.23,12.06 34.82,12.06 34.82,16.61 34.95,16.74 38.07,16.74
48V0_GTRB on TOP (solid shape): 34.14,18.31 34.14,17.45 30.43,17.45 30.28,17.6 30.28,18.31 30.43,18.47 33.99,18.47
48V0_GTRB on TOP (solid shape): 64.85,10.03 64.85,8.81 64.31,8.28 57.2,8.28 56.69,8.79 56.69,10.31 64.57,10.31
48V0_GTRB on BOTTOM (solid shape): 25.7,16.46 25.7,15.49 25.32,15.11 25.32,12.95 25.3,12.93 22.66,12.93 22.63,12.95 22.63,16.54 22.78,16.69 25.48,16.69
48V0_GTRB on BOTTOM (solid shape): 38.58,16.54 38.58,12.95 38.56,12.93 35.92,12.93 35.89,12.95 35.89,15.11 35.51,15.49 35.51,16.46 35.74,16.69 38.43,16.69
48V0_GTRB on L3_SIG (solid shape): 32.97,17.96 32.97,16.76 30.28,16.76 30.28,17.91 30.48,18.11 32.82,18.11
48V0_GTRB on L3_SIG (solid shape): 37.87,16.66 37.87,15.09 37.72,14.94 36.75,14.94 36.3,15.39 23.67,15.39 23.34,15.72 23.34,16.66 23.67,16.99 37.54,16.99
48V0_VIN on TOP (solid shape): 77.6,26.39 77.6,22.63 70.08,22.63 69.01,21.56 67.34,21.56 67.13,21.77 67.13,27.2 76.78,27.2
48V0_VIN on TOP (solid shape): 98.32,58.62 98.32,54.23 97.71,53.62 94.67,53.62 93.52,54.76 93.52,57.96 94.59,59.03 97.92,59.03
48V0_VIN on TOP (solid shape): 99.19,47.98 99.19,44.22 91.67,44.22 90.6,43.15 88.93,43.15 88.72,43.36 88.72,48.79 98.37,48.79
48V0_VIN on TOP (solid shape): 99.19,26.39 99.19,22.63 91.67,22.63 90.6,21.56 88.93,21.56 88.72,21.77 88.72,27.2 98.37,27.2
48V0_VIN on BOTTOM (solid shape): 77.93,26.19 77.93,22.07 77.77,21.92 73.43,21.92 73.43,23.7 75.18,25.45 75.18,26.29 75.34,26.44 77.67,26.44
48V0_VIN on BOTTOM (solid shape): 99.52,47.78 99.52,43.66 99.36,43.51 95.02,43.51 95.02,45.29 96.77,47.04 96.77,47.88 96.93,48.03 99.26,48.03
48V0_VIN on BOTTOM (solid shape): 99.52,26.19 99.52,22.07 99.36,21.92 95.02,21.92 95.02,23.7 96.77,25.45 96.77,26.29 96.93,26.44 99.26,26.44
48V0_VIN on L4_PWR (solid shape): outline of 1965 points within 64.82,14.6 98.73,58.83
+12V0 on BOTTOM (solid shape): 44.17,33.78 44.17,33.63 42.55,33.63 42.06,34.11 42.06,35.08 42.21,35.23 42.72,35.23
+12V0 on TOP: 44.09,36.25 44.09,33.78 44.04,33.73 41.99,33.73 41.07,34.65 41.07,36.07 41.25,36.25
+12V0 on L4_PWR: outline of 189 points within 10.64,33.6 62.84,60.88
-12V0 on BOTTOM (solid shape): 60.76,42.75 60.76,41.78 60.63,41.66 59.41,41.66 59.28,41.78 58.78,41.78 58.72,41.83 58.72,41.96 59.66,42.9 60.6,42.9
-12V0 on TOP: 56.34,39.27 56.34,42.37 56.87,42.9 60.96,42.9 61.57,42.29 61.57,39.27
-12V0 on L4_PWR: outline of 161 points within 8.31,30.45 69.55,63.6
GND on TOP (solid shape): 83.34,56.9 83.34,52.93 83.16,52.76 80.44,52.76 80.44,55.6 81.91,57.07 83.16,57.07
GND on TOP (solid shape): 77.6,14.6 74.55,11.56 68.1,11.56 68.1,14.43 68.3,14.63 69.57,14.63 70.05,15.11 70.05,19.94 77.6,19.94
GND on TOP (solid shape): 99.19,36.19 96.14,33.15 89.69,33.15 89.69,36.02 89.89,36.22 91.16,36.22 91.64,36.7 91.64,41.53 99.19,41.53
GND on TOP (solid shape): 99.19,14.6 96.14,11.56 89.69,11.56 89.69,14.43 89.89,14.63 91.16,14.63 91.64,15.11 91.64,19.94 99.19,19.94
GND on TOP (solid shape): 13.03,17.93 13.03,15.6 14.43,14.2 14.43,10.57 15.9,9.09 15.9,7.37 15.75,7.21 11.43,7.21 11.28,7.37 11.28,9.09 12.75,10.57 12.75,14.25 12.4,14.6 10.69,14.6 10.29,15.01 10.29,17.88 10.49,18.08 12.88,18.08
GND on TOP (solid shape): 30.05,17.93 30.05,15.6 31.45,14.2 31.45,10.57 32.92,9.09 32.92,7.37 32.77,7.21 28.45,7.21 28.3,7.37 28.3,9.09 29.77,10.57 29.77,14.25 29.41,14.6 27.71,14.6 27.3,15.01 27.3,17.88 27.51,18.08 29.9,18.08
GND on TOP (solid shape): 47.07,17.93 47.07,15.6 48.46,14.2 48.46,10.57 49.94,9.09 49.94,7.37 49.78,7.21 45.47,7.21 45.31,7.37 45.31,9.09 46.79,10.57 46.79,14.25 46.43,14.6 44.73,14.6 44.32,15.01 44.32,17.88 44.53,18.08 46.91,18.08
GND on TOP (solid shape): 68.78,52.12 68.78,51.23 68.91,51.1 69.8,51.1 69.93,50.98 69.93,48.44 70.18,48.18 71.32,48.18 71.45,48.06 79.2,48.06 79.45,47.8 79.45,43.36 79.2,43.1 77.04,43.1 74.75,45.39 74.75,46.28 74.63,46.41 71.45,46.41 71.2,46.15 64.97,46.15 64.97,48.82 68.4,52.25 68.66,52.25
GND on TOP (solid shape): 64.28,58 64.33,57.98 64.38,57.97 67.3,57.97 67.42,57.85 67.42,57.42 67.48,57.28 67.63,57.22 68.25,57.22 68.32,57.19 68.35,57.12 68.35,56.14 68.32,56.07 68.25,56.04 67.63,56.04 67.48,55.98 67.42,55.83 67.42,55.41 67.32,55.31 64.38,55.31 64.33,55.3 64.28,55.28 64.26,55.27 62.89,55.27 62.82,55.3 62.79,55.37 62.79,57.91 62.82,57.98 62.89,58.01 64.26,58.01
GND on TOP (solid shape): outline of 81 points within 40.03,25.93 63.04,46.41
GND on BOTTOM (solid shape): 12.55,9.09 12.55,7.37 12.42,7.24 9.52,7.24 9.52,9.22 12.42,9.22
GND on BOTTOM (solid shape): 17.65,7.24 14.76,7.24 14.63,7.37 14.63,9.09 14.76,9.22 17.65,9.22
GND on BOTTOM (solid shape): 29.57,9.09 29.57,7.37 29.44,7.24 26.54,7.24 26.54,9.22 29.44,9.22
GND on BOTTOM (solid shape): 34.67,7.24 31.78,7.24 31.65,7.37 31.65,9.09 31.78,9.22 34.67,9.22
GND on BOTTOM (solid shape): 46.58,9.09 46.58,7.37 46.46,7.24 43.56,7.24 43.56,9.22 46.46,9.22
GND on BOTTOM (solid shape): 51.69,7.24 48.79,7.24 48.67,7.37 48.67,9.09 48.79,9.22 51.69,9.22
GND on BOTTOM (solid shape): 77.93,18.64 77.93,12.67 77.6,12.34 72.67,12.34 72.44,12.57 72.44,18.67 77.9,18.67
GND on BOTTOM (solid shape): 99.52,40.23 99.52,34.26 99.19,33.93 94.26,33.93 94.03,34.16 94.03,40.26 99.49,40.26
GND on BOTTOM (solid shape): 99.52,18.64 99.52,12.67 99.19,12.34 94.26,12.34 94.03,12.57 94.03,18.67 99.49,18.67
GND on BOTTOM (solid shape): 66.09,17.75 66.01,17.68 64.9,17.68 64.72,17.5 64.72,16.81 64.59,16.69 64.06,16.69 64.06,18.34 64.47,18.75 64.47,23.11 66.09,23.11
GND on BOTTOM (solid shape): 87.68,39.34 87.6,39.27 86.49,39.27 86.31,39.09 86.31,38.4 86.18,38.28 85.65,38.28 85.65,39.93 86.06,40.34 86.06,44.7 87.68,44.7
GND on BOTTOM (solid shape): 87.68,17.75 87.6,17.68 86.49,17.68 86.31,17.5 86.31,16.81 86.18,16.69 85.65,16.69 85.65,18.34 86.06,18.75 86.06,23.11 87.68,23.11
GND on BOTTOM (solid shape): 93.57,35.56 93.57,34.06 93.77,33.86 93.82,33.64 93.63,33.52 93.07,33.52 93.07,35.59 93.55,35.59
GND on TOP: 71.12,10.85 77.06,10.85 77.62,10.29 77.62,9.12 79.12,7.62 80.23,7.62 80.23,7.06 80.2,6.99 80.12,6.96 78.81,6.96 78.64,7.04 78.61,7.23 78.63,7.3 78.64,7.38 78.5,7.7 78.1,7.83 78.02,7.81 77.99,7.8 77.9,7.86 77.82,7.94 77.71,7.98 76.72,7.98 76.58,7.92 76.52,7.77 76.52,7.06 76.49,6.99 76.42,6.96 72.07,6.96 71.9,7.05 71.88,7.23 71.9,7.31 71.91,7.39 71.77,7.72 71.45,7.85 71.41,7.85 71.36,7.84 71.19,7.88 71.12,8.04
GND on TOP: 29.03,9.83 32.18,9.83 32.92,9.09 32.92,6.12 34.16,4.88 34.16,1.57 33.86,1.27 31.19,1.27 30.94,1.52 30.94,4.72 28.3,7.37 28.3,9.09
GND on TOP: 40.28,50.4 40.35,50.55 40.51,50.6 40.56,50.6 40.88,50.6 40.91,50.57 40.97,50.53 41.04,50.52 41.66,50.52 41.66,50.1 41.02,50.1 40.87,50.04 40.81,49.9 40.81,49.16 40.87,49.02 41.02,48.96 42.65,48.96 42.77,49 42.85,49.1 42.86,49.13 42.91,49.17 43.83,49.17 43.99,49.1 44.03,48.93 44.02,48.88 44.02,48.84 44.15,48.51 44.48,48.38 44.51,48.38 44.68,48.32 44.73,48.15 44.73,48.13 44.73,47.54 44.79,47.4 44.93,47.34 45.59,47.34 45.74,47.4 45.8,47.54 45.8,48.13 45.8,48.15 45.85,48.32 46.01,48.38 46.09,48.38 46.25,48.32 46.31,48.15 46.3,48.13 46.3,47.43 46.24,47.4 46.19,47.37 46.14,47.33 45.82,47.02 44.53,47.02 43.52,48.02 43.42,48.08 43.31,48.11 40.66,48.11 40.28,48.49
GND on TOP: 12.01,9.83 15.16,9.83 17.6,7.39 17.6,6.72 17.6,6.63 18.8,5.44 18.8,4.09 18.75,4.01 18.73,3.99 18.3,3.53 18.15,2.92 19.43,1.64 20.71,2.92 20.6,3.45 20.27,3.89 20.25,3.9 20.22,3.98 20.22,5.69 20.4,5.87 22.1,5.87 22.4,5.56 22.4,3.99 23.98,2.41 23.98,1.4 23.85,1.27 6.25,1.27 5.94,1.57 5.94,3.28 5.95,3.41 5.96,3.53 5.25,5.25 3.53,5.96 3.4,5.95 3.28,5.94 1.45,5.94 1.27,6.12 1.27,6.55 1.29,6.57 5.83,6.57 5.86,6.55 5.91,6.53 5.97,6.52 6.86,6.52 6.93,6.49 6.96,6.42 6.96,5.79 7.01,5.52 7.17,5.29 9.25,3.21 9.27,3.17 9.27,3.12 9.26,3.02 9.26,2.92 11.45,2.01 10.54,4.2 10.44,4.2 10.34,4.19 10.29,4.19 10.25,4.22 8.38,6.09 8.38,6.42 8.41,6.49 8.48,6.52 9.37,6.52 9.52,6.58 9.58,6.72 9.58,7.39
GND on TOP: outline of 538 points within 17.07,38.18 63.25,65.07
GND on TOP: 85.22,45.14 88.09,45.14 88.52,44.7 88.52,43.27 88.52,43.27 88.52,38.71 88.21,38.4 85.12,38.4 84.81,38.71 84.81,44.73
GND on TOP: 50.06,45.26 48.39,45.26 48.26,45.14 48.26,43.36 48.39,43.23 50.06,43.23 50.19,43.36 50.19,45.14
GND on TOP: 51,25.2 51,19.25 50.8,19.05 50.27,19.05 50.2,19.08 50.17,19.15 50.17,19.71 50.11,19.85 49.97,19.91 49.5,19.91 49.43,19.94 49.4,20.02 49.4,25.17 49.56,25.32 50.88,25.32
GND on TOP: 46.05,9.83 49.2,9.83 49.94,9.09 49.94,6.45 51.41,4.98 51.41,1.52 51.16,1.27 48.56,1.27 48.41,1.42 48.41,4.27 45.31,7.37 45.31,9.09
GND on TOP: 85.22,23.55 88.09,23.55 88.52,23.11 88.52,21.68 88.52,21.68 88.52,17.12 88.21,16.81 85.12,16.81 84.81,17.12 84.81,23.14
GND on TOP: 50.19,20.32 50.19,19.15 50.29,19.05 50.98,19.05 52.76,17.27 54.56,17.27 55.37,18.08 55.37,22.78 55.02,23.14 54.18,23.14 53.87,22.83 53.87,20.8 53.39,20.32
GND on TOP: outline of 431 points within 1.27,33.45 63.92,67.31
GND on TOP: 63.63,23.55 66.5,23.55 66.93,23.11 66.93,21.68 66.93,21.68 66.93,17.12 66.62,16.81 63.53,16.81 63.22,17.12 63.22,23.14
GND on TOP: 62.64,36.73 62.66,36.73 64.62,34.77 64.62,30.99 64.76,30.85 68.92,30.85 68.94,30.86 77.04,30.86 78.61,29.29 93.29,29.29 93.75,28.83 93.75,28.17 60.88,28.17 58.65,25.93 56.54,25.93 56.44,26.03 56.44,26.37 58.93,28.85 58.85,28.93 58.85,30.05 62.28,33.48 62.28,36.37
GND on TOP: outline of 158 points within 1.27,5.82 15.57,37.03
GND on TOP: 58.6,43.36 59.26,43.36 59.56,43.66 59.56,45.24 59.41,45.39 58.45,45.39 58.29,45.24 58.29,43.66
GND on TOP: 41.83,25.2 41.83,19.25 41.63,19.05 41.1,19.05 41.03,19.08 41,19.15 41,19.71 40.94,19.85 40.8,19.91 40.34,19.91 40.26,19.94 40.23,20.02 40.23,25.17 40.39,25.32 41.71,25.32
GND on TOP: 12.06,19.56 12.06,25.12 14.81,25.12 14.81,19.56
GND on TOP: 39.09,5.89 40.03,5.89 40.39,5.54 40.39,3.58 42.24,1.73 42.24,1.4 42.11,1.27 39.65,1.27 39.52,1.4 39.52,4.57 38.96,5.13 38.96,5.77
GND on TOP: outline of 122 points within 79.88,1.27 100.33,59.51
GND on TOP: outline of 205 points within 33.63,16.66 58.63,34.62
GND on TOP: outline of 82 points within 26.52,19.63 34.52,26.05
GND on TOP: outline of 153 points within 55.93,1.27 94.03,10.44
GND on TOP: 42.26,47.41 42.43,47.5 43.18,47.5 44.18,46.49 44.28,46.43 44.4,46.41 45.95,46.41 46.07,46.43 46.16,46.49 46.48,46.81 49.5,46.81 49.62,46.83 49.72,46.9 50.11,47.29 50.59,47.29 50.74,47.23 50.79,47.08 50.79,47.04 51.25,46.58 51.71,47.04 51.71,47.08 51.76,47.23 51.91,47.29 52.96,47.29 53,47.28 53.03,47.28 54.18,47.28 54.18,45.85 46.41,45.85 45.44,44.88 42.39,44.88 40.56,43.05 40.56,42.97 40.48,42.81 40.3,42.78 40.23,42.79 40.16,42.8 39.7,42.34 40.16,41.88 40.23,41.89 40.3,41.91 40.48,41.88 40.56,41.71 40.56,41.33 40.3,41.06 40.12,41 39.97,41.11 39.95,41.15 39.92,41.19 39.79,41.31 39.81,41.37 39.82,41.44 39.83,41.5 39.7,41.82 39.38,41.96 39.34,41.96 38.79,42.52 38.79,45.85 40.44,47.5 41.21,47.5 41.37,47.41 41.39,47.22 41.37,47.13 41.36,47.04 41.82,46.58 42.27,47.04 42.27,47.13 42.24,47.22
GND on TOP: outline of 144 points within 53.9,43.92 100.33,67.31
GND on TOP: 44.07,25.32 47.98,25.32 48.36,24.94 48.36,24.79 46.98,24.79 46.71,24.52 46.71,22.91 46.61,22.59 46.7,22.27 46.71,22.25 46.71,22.09 47.07,21.73 47.07,17.6 46.96,17.5 44.91,17.5 44.75,17.35 44.75,16.8 44.63,16.61 44.41,16.65 43.33,17.73 34.49,17.73 34.42,17.81 34.42,18.36 34.54,18.49 36.93,18.49 37.05,18.51 37.15,18.58 37.57,19 39.01,19 39.03,18.95 39.11,18.87 39.21,18.85 40.8,18.85 40.92,18.89 41,19 41,19.05 41,19.71 41,19.76 41,20.7 41.22,20.93 41.85,20.93 41.93,20.88 41.95,20.87 41.99,20.81 42.05,20.77 42.14,20.73 42.23,20.72 42.41,20.72 42.5,20.71 42.9,20.71 43.07,20.55 44.26,20.55 44.58,20.87 44.58,24.49 44.28,24.79 43.82,24.79 43.76,24.83 43.74,24.89 43.74,24.99
GND on TOP: 18.34,20.9 24.28,20.9 24.49,20.7 24.49,20.17 24.46,20.1 24.39,20.07 23.83,20.07 23.68,20.01 23.62,19.87 23.62,19.41 23.59,19.33 23.52,19.3 18.36,19.3 18.21,19.46 18.21,20.78
GND on TOP: 44.09,33.27 43.43,33.27 43.13,32.97 43.13,31.39 43.28,31.24 44.25,31.24 44.4,31.39 44.4,32.97
GND on TOP: 57.94,32.13 56.77,32.13 56.57,31.93 56.57,29.57 56.85,29.29 57.86,29.29 58.14,29.57 58.14,31.93
GND on TOP: 15.72,46.1 16.71,46.1 17.02,45.8 17.02,45.41 16.03,44.42 15.42,44.42 15.22,44.63 15.22,45.59
GND on BOTTOM: 61.95,52.3 61.95,49.78 60.88,48.72 57.1,48.72 57.1,46.89 57.43,46.56 60.3,46.56 63.78,50.04 63.78,51.41 63.75,51.44 64.54,52.22 64.57,52.22 64.57,52.48 64.47,52.58 62.23,52.58
GND on BOTTOM: 51.77,56.77 52.02,56.77 52.02,54.81 52.02,54.8 52.02,51.93 52.02,51.92 52.02,49.73 52.05,49.63 52.12,49.56 52.12,49.07 52.1,49 52.09,48.92 52.55,48.46 53.01,48.92 53.01,48.94 53.01,49.33 53.21,49.53 53.48,49.53 53.49,49.53 53.85,49.53 54.33,49.05 54.33,46.89 53.11,45.67 50.67,45.67 50.38,45.96 50.28,46.03 50.16,46.05 48.41,46.05 48.3,46.03 48.2,45.96 48.01,45.77 47.57,45.34 46.79,44.55 45.16,44.55 44.84,44.88 44.84,45.45 45.31,45.92 45.77,45.92 45.91,45.95 46.02,46.03 46.91,46.92 46.91,46.91 47.42,47.42 47.68,47.42 47.7,47.42 48.02,47.56 48.16,47.88 48.15,47.95 48.13,48.03 48.13,48.66 48.14,48.72 48.15,48.78 48.01,49.1 47.69,49.23 47.55,49.2 47.43,49.14 47.41,49.13 47.24,49.11 47.11,49.23 47.1,49.26 47.06,49.34 47.01,49.4 46.63,49.78 46.63,54.79 48,56.16 48.4,56.16 48.54,56.08 48.69,56.06 49.01,56.19 49.14,56.55 49.2,56.71 49.35,56.77 50.75,56.77 50.75,54.81 50.81,54.67 50.95,54.61 51.56,54.61 51.71,54.67 51.77,54.81
GND on BOTTOM: outline of 131 points within 45.87,55.6 52.02,67.31
GND on BOTTOM: 47.07,15.82 50.32,15.82 51.46,14.68 51.46,14.43 51.36,14.33 51.01,14.33 50.99,14.35 50.86,14.44 50.71,14.47 50.56,14.47 50.52,14.49 50.5,14.5 50.43,14.56 50.34,14.58 48.82,14.58 48.67,14.52 48.62,14.38 48.62,12.09 48.67,11.95 48.82,11.89 50.04,11.89 50.11,11.86 50.14,11.79 50.14,11.71 50.11,11.64 50.04,11.61 49.66,11.61 49.51,11.55 49.45,11.4 49.45,9.88 49.51,9.74 49.66,9.68 50.04,9.68 50.11,9.65 50.14,9.58 50.14,9.49 50.1,9.44 50.07,9.43 49.96,9.35 49.92,9.23 49.92,7 50.52,6.4 50.52,5.56 50.24,5.28 45.49,5.28 44.91,5.87 44.91,6.54 45.33,6.96 45.33,11.57 44.7,12.19 44.7,12.26 44.7,12.55 44.74,12.58 44.77,12.62 44.86,12.72 44.99,12.73 45.04,12.73 45.09,12.72 45.41,12.86 45.54,13.18 45.54,13.21 45.54,14.02 45.54,14.07 45.54,14.3
GND on BOTTOM: 6.3,67.31 12.55,67.31 12.75,67.11 12.75,66.55 12.65,66.45 12.39,66.45 12.13,66.71 11.81,66.93 11.43,67.01 10.75,66.72 10.46,66.04 10.47,65.96 10.48,65.89 10.48,65.85 10.58,65.58 11.07,65.03 11.07,63.68 10.82,63.42 10.14,63.42 10.08,63.47 10.08,63.93 10.49,64.34 10.5,64.34 10.64,64.5 10.69,64.77 10.68,64.82 10.52,65.08 10.24,65.18 10,65.18 9.94,65.19 9.92,65.22 9.85,65.27 9.76,65.29 8.95,65.29 8.12,65.29 8.02,65.26 7.95,65.19 7.89,65.14 7.82,65.14 7.74,65.17 7.64,65.18 7.36,65.08 7.2,64.82 7.19,64.77 7.19,64.72 7.24,64.51 7.38,64.34 7.39,64.34 7.8,63.93 7.8,60.4 7.8,60.39 7.8,58.62 5.39,56.22 5.28,56.05 5.24,55.85 5.24,55.8 5.24,51.92 1.27,51.92 1.27,59.89 1.47,60.1 2.08,60.1 2.2,60.08 2.31,60.07 3.03,60.37 3.33,61.09 3.32,61.2 3.3,61.32 3.3,62.31 3.65,62.65 3.69,62.66 5.28,63.42 5.93,65.07 5.93,65.2 5.92,65.33 5.92,66.93
GND on BOTTOM: 1.27,13.39 4.98,13.39 4.98,11.91 1.27,11.91
GND on BOTTOM: 30.05,15.82 33.3,15.82 34.44,14.68 34.44,14.43 34.34,14.33 33.99,14.33 33.97,14.35 33.84,14.44 33.69,14.47 33.54,14.47 33.5,14.49 33.48,14.5 33.41,14.56 33.32,14.58 31.8,14.58 31.66,14.52 31.6,14.38 31.6,12.09 31.66,11.95 31.8,11.89 33.02,11.89 33.09,11.86 33.12,11.79 33.12,11.71 33.09,11.64 33.02,11.61 32.64,11.61 32.49,11.55 32.44,11.4 32.44,9.88 32.49,9.74 32.64,9.68 33.02,9.68 33.09,9.65 33.12,9.58 33.12,9.49 33.08,9.44 33.05,9.43 32.95,9.35 32.91,9.23 32.91,7 33.5,6.4 33.5,5.56 33.22,5.28 28.47,5.28 27.89,5.87 27.89,6.54 28.31,6.96 28.31,11.57 27.69,12.19 27.69,12.26 27.69,12.55 27.72,12.58 27.75,12.62 27.84,12.72 27.97,12.73 28.02,12.73 28.07,12.72 28.39,12.86 28.52,13.18 28.52,13.21 28.52,14.02 28.52,14.07 28.52,14.3
GND on BOTTOM: 56.46,57.61 58.12,57.61 58.22,57.51 58.22,55.07 58.06,54.91 57.6,54.91 57.56,54.92 56.9,54.92 56.75,54.86 56.69,54.72 56.69,54.13 56.69,54.12 56.69,53.73 56.69,53.72 56.69,53.13 56.75,52.99 56.9,52.93 57.56,52.93 57.7,52.99 57.76,53.13 57.76,53.62 57.94,53.8 60.2,53.8 60.22,53.82 60.35,53.82 60.4,53.81 60.44,53.81 60.69,53.92 60.8,54.17 60.8,54.7 60.78,54.82 60.72,54.92 60.7,55.13 60.88,55.24 61.45,55.24 61.59,55.3 61.65,55.45 61.65,56.01 61.68,56.08 61.75,56.11 62.05,56.11 62.51,55.65 62.51,50.04 62.36,49.89 62.06,49.89 61.99,49.92 61.96,49.99 61.96,50.55 61.9,50.69 61.75,50.75 61.29,50.75 61.22,50.78 61.19,50.85 61.19,51.97 60.99,52.17 58.39,52.17 57.81,51.59 57.81,48.56 57.66,48.41 56.44,48.41 56.29,48.56 56.29,57.43
GND on BOTTOM: 40.77,67.31 43.1,67.31 43.23,67.18 43.23,66.52 43.1,66.4 42.92,66.4 42.61,66.71 42.3,66.92 41.93,67.01 41.91,67.01 40.94,66.04 41.91,65.07 41.93,65.07 42.3,65.16 42.61,65.37 42.82,65.58 43.05,65.58 43.23,65.4 43.23,64.22 42.19,64.22 41.91,64.23 41.91,64.24 41.22,64.24 40.59,64.87 40.59,67.13
GND on BOTTOM: outline of 151 points within 20.62,40.79 34.87,59.08
GND on BOTTOM: 75.13,3.07 76.91,3.07 76.91,1.27 75.13,1.27
GND on BOTTOM: 13.03,15.82 16.28,15.82 17.42,14.68 17.42,14.43 17.32,14.33 16.97,14.33 16.95,14.35 16.82,14.44 16.67,14.47 16.52,14.47 16.48,14.49 16.47,14.5 16.4,14.56 16.31,14.58 14.78,14.58 14.64,14.52 14.58,14.38 14.58,12.09 14.64,11.95 14.78,11.89 16,11.89 16.07,11.86 16.1,11.79 16.1,11.71 16.07,11.64 16,11.61 15.62,11.61 15.48,11.55 15.42,11.4 15.42,9.88 15.48,9.74 15.62,9.68 16,9.68 16.07,9.65 16.1,9.58 16.1,9.49 16.06,9.44 16.03,9.43 15.93,9.35 15.89,9.23 15.89,7 16.48,6.4 16.48,5.56 16.21,5.28 11.46,5.28 10.87,5.87 10.87,6.54 11.29,6.96 11.29,11.57 10.67,12.19 10.67,12.26 10.67,12.55 10.7,12.58 10.73,12.62 10.82,12.72 10.95,12.73 11,12.73 11.05,12.72 11.37,12.86 11.51,13.18 11.51,13.21 11.51,14.02 11.51,14.07 11.51,14.3
GND on BOTTOM: outline of 317 points within 29.26,40.44 46.41,63.09
GND on BOTTOM: 33.12,67.31 35.41,67.31 35.61,67.11 35.61,66.59 35.54,66.43 35.37,66.39 35.3,66.4 34.98,66.71 34.67,66.93 34.29,67.01 33.66,66.77 33.33,66.18 33.32,66.12 32.97,66.12 32.97,67.16
GND on BOTTOM: outline of 164 points within 54.58,25.6 100.33,45.62
GND on BOTTOM: 17.73,67.31 20.14,67.31 20.37,67.08 20.37,66.37 20.3,66.29 20.16,66.29 19.75,66.71 19.43,66.93 19.05,67.01 18.52,66.85 18.16,66.42 18.1,66.2 18.09,65.95 18.18,65.62 18.38,65.34 18.59,65.19 18.82,65.1 18.94,65.08 19.05,65.07 19.51,65.07 19.57,65.02 20.19,64.39 20.19,63.4 20.02,63.22 19.76,63.22 19.54,63.45 19.54,63.65 19.53,63.69 19.53,64.01 19.47,64.16 19.33,64.22 18.45,64.22 18.37,64.24 18.33,64.24 18.11,64.24 18.1,64.25 17.97,64.25 17.73,64.49
GND on BOTTOM: 25.53,67.31 27.79,67.31 27.99,67.11 27.99,66.4 27.89,66.29 27.78,66.29 27.37,66.71 27.05,66.93 26.67,67.01 25.7,66.04 26.67,65.07 27.13,65.07 27.81,64.39 27.81,63.6 27.61,63.4 26.77,63.4 26.7,63.47 26.7,64.01 26.64,64.16 26.49,64.22 25.67,64.22 25.35,64.54 25.35,67.13
GND on BOTTOM: outline of 185 points within 1.27,19.53 18.08,53.7
GND on BOTTOM: 32.97,66.35 33.21,66.43 33.34,66.21 33.33,66.13 33.32,66.04 33.61,65.36 34.29,65.07 34.4,65.08 34.51,65.1 35.41,65.1 35.61,64.9 35.61,64.22 35.05,64.22 34.98,64.23 34.95,64.23 34.34,64.23 34.34,64.24 33.93,64.24 33.91,64.25 33.86,64.27 33.81,64.28 33.46,64.28 32.97,64.77
GND on BOTTOM: outline of 133 points within 12.65,42.55 21.11,62.1
GND on BOTTOM: 38.76,42.65 38.99,42.65 39.04,42.64 39.5,42.64 39.57,42.63 39.62,42.6 39.62,42.09 39.5,41.96 39.37,41.96 39.05,41.83 38.91,41.5 38.92,41.43 38.94,41.35 38.94,40.82 38.56,40.44 38.21,40.44 38.11,40.48 38,40.49 37.89,40.48 37.79,40.44 37.46,40.44 37.34,40.49 37.21,40.51 37.08,40.49 36.96,40.44 36.2,40.44 36.03,40.62 35.79,40.69 35.75,40.69 35.67,40.72 35.64,40.79 35.64,40.89 35.84,41.1 35.99,41.16 36.13,41.1 36.19,41.06 36.27,41.05 38.46,41.05 38.6,41.11 38.66,41.25 38.66,41.86 38.6,42 38.46,42.06 37.41,42.06 37.41,42.32 38.46,42.32 38.6,42.38 38.66,42.52 38.66,42.55
GND on BOTTOM: outline of 826 points within 1.27,1.27 100.33,67.31
GND on L2_GND: 6.22,67.31 95.35,67.31 95.68,66.98 95.68,64.87 97.89,62.66 99.85,62.66 100.33,62.18 100.33,6.25 100.03,5.94 97.89,5.94 95.66,3.71 95.66,1.63 95.3,1.27 6.25,1.27 5.94,1.57 5.94,3.58 3.58,5.94 1.45,5.94 1.27,6.12 1.27,22.35 6.02,22.35 6.02,27.28 3.63,27.28 3.63,30.38 6.02,30.38 6.02,33.45 1.27,33.45 1.27,62.36 1.57,62.66 3.66,62.66 5.92,64.92 5.92,67.01 ; 1 cut-out
GND on L3_SIG: 48.79,23.85 49.05,23.85 49.07,23.85 51.07,23.85 51.16,23.76 51.16,23.34 51.19,23.17 51.29,23.02 51.75,22.56 51.89,22.46 52.07,22.43 54.57,22.43 55.16,21.84 55.21,21.61 55.02,21.49 54.19,21.49 54.07,21.47 53.97,21.4 53.22,20.65 40.65,20.65 40.53,20.63 40.43,20.56 39.99,20.12 38.31,20.12 38.31,20.12 38.16,20.23 37.97,20.27 37.76,20.22 37.6,20.07 37.45,19.98 37.28,20.04 37.06,20.27 37.06,22.58 37.64,23.16 37.87,23.16 37.95,23.15 38.02,23.14 38.1,23.15 38.18,23.16 38.58,23.16 38.66,23.15 38.73,23.14 38.98,23.21 39.15,23.4 39.6,23.85 41.99,23.85 42.01,23.85 42.49,23.85 42.9,23.44 43.07,23.22 43.33,23.14 43.35,23.14 44.02,23.14 44.07,23.14 47.17,23.14 47.21,23.14 47.88,23.14 47.93,23.14 48.13,23.2 48.28,23.34
GND on L3_SIG: 38.05,32.84 38.43,32.84 38.44,32.83 42.52,28.75 42.52,25.5 41.78,24.77 40.17,24.77 39.98,24.89 40.02,25.11 40.09,25.18 40.16,25.28 40.18,25.4 40.18,26.11 40.16,26.23 40.09,26.33 39.79,26.63 39.69,26.7 39.57,26.72 37.85,26.72 37.69,26.87 37.69,32.49
GND on L3_SIG: 52.35,18.36 56.29,18.36 61.96,12.69 62.06,12.62 62.18,12.6 63.75,12.6 66.17,10.19 66.17,8.31 66.19,8.19 66.26,8.09 67.61,6.73 67.41,6.53 67.35,6.53 65.18,8.7 65.18,9.93 65.11,10.25 64.93,10.52 64.77,10.69 63.43,12.02 63.16,12.2 62.84,12.27 58.82,12.27 55.09,15.99 55.09,16.75 54.64,17.2 50.22,17.2 50.19,17.2 50.19,17.88 51.74,17.88 51.86,17.9 51.96,17.97
GND on L3_SIG: 42.65,48.29 46.33,48.29 46.51,48.11 46.51,47.7 46.36,47.55 43.81,47.55 43.7,47.53 43.6,47.46 40.56,44.43 34.32,44.43 34.2,44.4 34.1,44.34 31.5,41.73 29.79,41.73 28.02,43.51 28.02,45.42 29.72,47.12 30.61,47.12 31.11,46.61 32.52,45.2 32.62,45.13 32.74,45.11 39.34,45.11 39.46,45.13 39.56,45.2 41.15,46.79 41.31,46.84 41.45,46.76 41.61,46.63 41.82,46.58 42.14,46.72 42.27,47.04 42.27,47.09 42.26,47.14 42.2,47.29 42.1,47.4 42.01,47.55 42.07,47.71
GND on L3_SIG: outline of 224 points within 67.13,1.27 100.33,67.31
GND on L3_SIG: 8.01,54.39 8.23,54.43 8.36,54.25 8.36,50.16 6.98,48.78 6.76,48.74 6.63,48.93 6.63,53.01
GND on L3_SIG: 23.42,21.41 23.62,21.41 23.71,21.32 23.81,21.26 23.93,21.23 28.65,21.23 30.24,19.65 30.34,19.58 30.45,19.56 35.36,19.56 35.46,19.58 35.56,19.63 35.61,19.63 36.39,18.85 37.07,18.17 37.17,18.11 37.29,18.08 42.55,18.08 42.66,18.11 42.76,18.17 42.95,18.36 46.97,18.36 47.16,18.24 47.12,18.02 47.09,17.99 47.09,17.2 47.06,17.2 47.04,17.2 40.61,17.2 40.16,16.75 40.16,16.15 38.08,16.15 38.08,16.75 37.63,17.2 33.2,17.2 33.17,17.2 33.17,18.04 32.9,18.31 30.4,18.31 30.07,17.99 30.07,17.2 30.05,17.2 30.02,17.2 23.59,17.2 23.14,16.75 23.14,16.05 22.61,16.05 22.61,20.6
GND on L3_SIG: 33.23,25.88 33.3,25.91 33.73,25.91 34.77,24.87 34.77,24.83 34.91,24.51 35.23,24.38 35.36,24.4 35.48,24.46 35.68,24.46 35.79,24.28 35.79,23.39 35.81,23.28 35.88,23.18 36.02,23.04 36.02,20.71 35.93,20.54 35.74,20.52 35.67,20.54 35.59,20.55 35.32,20.46 35.15,20.24 35.13,20.17 30.58,20.17 29.13,21.62 33.11,25.59 33.17,25.69 33.2,25.81
GND on L3_SIG: outline of 248 points within 12.55,47.19 51.36,59.49
GND on L3_SIG: outline of 302 points within 1.27,38.35 68.66,67.31
GND on L3_SIG: outline of 179 points within 1.27,1.27 68.38,16.46
GND on L3_SIG: 66.23,51.89 67.49,51.89 67.69,51.69 67.69,17.86 67.57,17.68 67.34,17.72 66.13,18.94 66.03,19 65.91,19.03 62.2,19.03 57.3,23.93 57.3,25.32 57.28,25.44 57.21,25.54 56.2,26.56 56.12,26.61 56.04,26.64 56.01,26.65 54.67,27.98 54.57,28.04 54.46,28.07 51.69,28.07 51.57,28.04 51.47,27.98 51.33,27.84 46.66,27.84 44.96,29.54 41,33.5 41,39.25 41,39.27 41,40.23 43.48,40.23 43.48,38.96 44.9,37.54 61.07,37.54 65,41.47 65,50.67 66.04,51.71
GND on L3_SIG: 54.48,20.47 55.35,20.47 56.09,19.73 56.14,19.51 55.95,19.38 52.05,19.38 51.94,19.36 51.84,19.29 51.44,18.9 50.51,18.9 50.12,19.29 50.02,19.36 49.9,19.38 42.66,19.38 42.54,19.36 42.44,19.29 42.25,19.1 40.9,19.1 40.71,19.23 40.76,19.45 40.94,19.63 53.52,19.63 53.63,19.66 53.73,19.72
GND on L3_SIG: outline of 266 points within 11.48,26.67 35.79,38.23
GND on L3_SIG: outline of 139 points within 1.27,15.54 23.88,53.11
GND on L4_PWR: outline of 210 points within 52.1,1.27 89.69,36.47
GND on L4_PWR: outline of 230 points within 1.27,1.27 100.33,67.31
GND on L4_PWR: outline of 127 points within 1.27,1.27 53.54,57.28
GND on L4_PWR: 78.08,29.57 78.08,27.56 80.64,27.56 80.64,29.57
GND on L4_PWR: outline of 100 points within 12.62,42.21 59.94,54.2
GND on L5_GND: 6.22,67.31 95.35,67.31 95.68,66.98 95.68,65.07 98.09,62.66 99.85,62.66 100.33,62.18 100.33,6.25 100.03,5.94 98.04,5.94 95.66,3.56 95.66,1.63 95.3,1.27 6.25,1.27 5.94,1.57 5.94,3.56 3.56,5.94 1.45,5.94 1.27,6.12 1.27,22.35 6.02,22.35 6.02,27.28 3.63,27.28 3.63,30.38 6.02,30.38 6.02,33.45 1.27,33.45 1.27,62.36 1.57,62.66 3.66,62.66 5.92,64.92 5.92,67.01 ; 1 cut-out
PGND on TOP: 1.27,32.92 5.38,32.92 5.49,32.82 5.49,30.89 3.12,30.89 3.1,30.86 3.1,26.8 3.12,26.77 5.49,26.77 5.49,22.99 5.36,22.86 1.52,22.86 1.27,23.11
UNNAMED_5_ADMAX17643_I170_LX on TOP (solid shape): 77.17,42.6 77.17,34.34 73.23,34.34 73.23,39.67 74.63,41.07 74.63,44.88 74.88,44.88
UNNAMED_5_CAP_I118_N1 on TOP: 56.34,37.74 61.59,37.74 61.59,34.14 61.24,33.78 56.44,33.78 55.17,35.05 55.17,36.58
UNNAMED_5_CAP_I118_N2 on TOP: 50.22,39.27 50.22,36.6 50.11,36.5 50.11,35.41 50.19,35.33 54.46,35.33 54.71,35.59 54.71,36.53 55.5,37.31 55.5,39.24 55.47,39.27
UNNAMED_5_DIOSCHOTTKY_I144_P on TOP: 42.95,39.27 48.23,39.27 48.23,36.63 48.34,36.53 48.34,35.43 48.23,35.33 47.14,35.33 46.89,35.08 45.72,35.08 45.72,36.25 45.49,36.47 43.26,36.47 42.95,36.78
UNNAMED_16_ADLTC7000_I34_TS on TOP (solid shape): 83.46,16.41 83.46,15.42 83.72,15.16 86.44,15.16 87.38,14.22 87.38,11.56 78.92,11.56 78.26,12.22 78.26,15.06 79.93,16.74 83.13,16.74
UNNAMED_16_CAP_I12_N1 on TOP (solid shape): 90.68,14.99 90.58,14.88 89,14.88 88.9,14.99 88.9,19.53 90.68,19.53
UNNAMED_16_CAP_I68_N2 on TOP (solid shape): 88.8,57.76 88.8,53.59 88.49,53.29 84.99,53.29 84.58,53.7 84.58,58.01 88.54,58.01
UNNAMED_16_CN2P_I62_N1 on TOP (solid shape): 92.61,65.3 92.61,60.15 91.49,59.03 83.57,59.03 78.79,54.25 74.5,54.25 74.42,54.33 74.42,58.29 74.96,58.83 76.89,58.83 81.69,63.63 87.33,63.63 89.43,65.74 92.18,65.74
UNNAMED_16_RES_I38_N2 on TOP (solid shape): 84.58,17.83 84.51,17.75 79.86,17.75 79.83,17.78 79.83,24.54 82.5,27.2 84.58,27.2
UNNAMED_17_ADLTC7000_I28_TS on TOP (solid shape): 83.46,38 83.46,37.01 83.72,36.75 86.44,36.75 87.38,35.81 87.38,33.15 78.92,33.15 78.26,33.81 78.26,36.65 79.93,38.33 83.13,38.33
UNNAMED_17_CAP_I4_N1 on TOP (solid shape): 90.68,36.58 90.58,36.47 89,36.47 88.9,36.58 88.9,41.12 90.68,41.12
UNNAMED_17_RES_I37_N1 on TOP (solid shape): 84.58,39.42 84.51,39.34 79.86,39.34 79.83,39.37 79.83,46.13 82.5,48.79 84.58,48.79
UNNAMED_18_ADLTC7000_I30_TS on TOP (solid shape): 61.87,16.41 61.87,15.42 62.13,15.16 64.85,15.16 65.79,14.22 65.79,11.56 57.33,11.56 56.67,12.22 56.67,15.06 58.34,16.74 61.54,16.74
UNNAMED_18_CAP_I4_N1 on TOP (solid shape): 69.09,14.99 68.99,14.88 67.41,14.88 67.31,14.99 67.31,19.53 69.09,19.53
UNNAMED_18_RES_I38_N1 on TOP (solid shape): 62.99,17.83 62.92,17.75 58.27,17.75 58.24,17.78 58.24,24.54 60.91,27.2 62.99,27.2
UNNAMED_19_ADMAX32666_I33_LXA on TOP (solid shape): 28.09,26.87 28.6,26.87 28.6,26.59 28.14,26.14 24.59,26.14 24.59,27.13 27.84,27.13
UNNAMED_19_ADMAX32666_I33_LXB on TOP (solid shape): 28.98,25.43 27.89,24.33 24.56,24.33 24.56,25.3 24.61,25.35 28.32,25.35 28.65,25.68 28.98,25.68
UNNAMED_21_ADLTC2992_I16_VDD on TOP (solid shape): 16.05,16.51 17.12,16.51 17.12,15.34 16.87,15.09 15.93,15.09 15.85,15.01 15.85,14.22 15.42,13.79 14.81,13.79 14.71,13.89 14.71,14.33 13.89,15.14 13.89,17.09 15.47,17.09
UNNAMED_21_ADLTC2992_I48_VDD on TOP (solid shape): 50.09,16.51 51.16,16.51 51.16,15.34 50.9,15.09 49.96,15.09 49.89,15.01 49.89,14.22 49.45,13.79 48.84,13.79 48.74,13.89 48.74,14.33 47.93,15.14 47.93,17.09 49.5,17.09
UNNAMED_21_CAP_I7_N1 on BOTTOM (solid shape): 21.56,8.33 20.47,7.24 18.9,7.24 18.9,11.66 21.56,11.66
UNNAMED_21_CAP_I23_N1 on BOTTOM (solid shape): 8.28,7.24 6.71,7.24 5.61,8.33 5.61,11.66 8.28,11.66
UNNAMED_21_CAP_I35_N1 on BOTTOM (solid shape): 55.6,8.33 54.51,7.24 52.93,7.24 52.93,11.66 55.6,11.66
UNNAMED_21_CAP_I45_N1 on BOTTOM (solid shape): 42.32,7.24 40.74,7.24 39.65,8.33 39.65,11.66 42.32,11.66
UNNAMED_22_ADLTC2992_I24_VDD on TOP (solid shape): 33.07,16.51 34.14,16.51 34.14,15.34 33.88,15.09 32.94,15.09 32.87,15.01 32.87,14.22 32.44,13.79 31.83,13.79 31.72,13.89 31.72,14.33 30.91,15.14 30.91,17.09 32.49,17.09
UNNAMED_22_CAP_I27_N1 on BOTTOM (solid shape): 25.3,7.24 23.72,7.24 22.63,8.33 22.63,11.66 25.3,11.66
UNNAMED_22_CAP_I36_N1 on BOTTOM (solid shape): 38.58,8.33 37.49,7.24 35.92,7.24 35.92,11.66 38.58,11.66
VREGO_A on L4_PWR (solid shape): 29.26,32.38 29.26,32.31 28.8,32.31 27.18,30.69 27.18,30.02 27.18,29.95 27.18,27.93 27.18,25.58 28.47,24.28 30.15,24.28 30.35,24.49 30.35,25.04 29.64,25.76 29.64,27.36 29.72,27.43 30.71,27.43 30.81,27.33 30.81,25.88 31.32,25.37 31.32,24.1 30.63,23.42 27.61,23.42 26.11,24.92 26.11,27.53 26.17,27.56 26.42,27.97 26.17,28.37 26.11,28.4 26.11,31.32 28.02,33.22 28.42,33.22

Small or netless copper shapes (teardrops, artwork): 144 on TOP, 5 on L4_PWR, 117 on BOTTOM, 90 on L3_SIG

## Text on the board
Ref Des/Silkscreen Bottom: GND | P2
User.Comments: DIRECTIVE 2002/95/EC). | 5.    SOLDER SHORT PINS BELOW: | WITH LEAD-FREE AND RoHS PCB ASSEMBLY STANDARDS (EU RoHS | 7.    INSTALL (N063458) V2016B HEATSINK ON TOP OF U6 (MAX17643ATC+) USING 468MP ADHESIVE TRANSFER TAPE | 6.    THESE FOLLOWING PARTS ARE DNI: | 4.    RoHS COMPLIANCE: ASSEMBLY VENDOR SHOULD ASSURE COMPLIANCE | 1 QTY OF (MFG PN = 1-5-468MP)TAPE CAN MAKE UP TO 1075 PCS OF 0.335"X0.335"(8.5mmx8.5mm) TAPE FOR V2016B HEATSINK | JP9 (PIN 1 & 2) | JP12 (PIN 2 & 3) | JP11 (PIN 2 & 3) | JP10 (PIN 1 & 2) | P11 | P8 | P10 | C10, C21, C164 | P7 | C85, C86, C115, C116, C191, C192 | C122, C123 | C54, C60, C197, C198, C207, C208 | R36 | R6, R28, R117 | P4 | R174, R175, R176, R178, R179 | C11, C22, C165 | R5, R14, R16, R27, R38, R116, R125, R127, R144 | P3 | P9
Ref Des/Silkscreen Top: AD-PAARRAY3552R-SL | 08-079905 REV C Z | PRIMARY SIDE | K
PAGE_OUTLINE: TEST PROCESS | N/A | REFERENCE LAYER | L2 | L5 | B | C | ECR-116325 | ECR-117464 | 15AUG23 | 08NOV23 | Z. ARCEO
BODY_CENTER: LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE.
DIMENSION: DIA MAX | TENTED VIA
User.11: SEE NOTE 7 | HEATSINK ASSEMBLY DETAILS | L2 | U6 | K | C27
User.15: FAB NOTES REVISION: 2ND NOVEMBER 2022 | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 6.   BOW & TWIST NOT TO EXCEED 0.0075 INCHES (0.75%) PER LINEAR INCH AND SHOULD BE MEASURED PER IPC-TM-650, METHOD 2.4.22. | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | ( ) FILLETS ALLOWED | ( ) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | ( ) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | ( ) GREEN | (X) OTHER_________ | (X) WHITE | ( ) OTHER | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | ( ) OTHER: | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X)  ISOLA 370HR OR EQUIVALENT | ( )  ISOLA-FR408HR OR EQUIVALENT | ( )  ISOLA IS410 | ( )  MEGTRON 6 | ( )  NELCO-4000-13 | ( )  ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( )  OTHER ________________________ | X | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | BLUE | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 26.  BOARDS TO BE SHIPPED SINGULATED AFTER FABRICATION PROCESS | 24.  MINIMUM DESIGN LINE WIDTH IS .004 INCH. | 25.  MINIMUM DESIGN LINE SPACING IS .004 INCH. | SMOOTHEN EDGES AND FREE FROM BURRS AFTER DEPANELIZATION PROCESS | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | ( )  NON-CONDUCTIVE EPOXY FILL ALL 0.0050 INCHES AND 0.XXXX INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | ( ) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | NOTES: UNITS IN INCH | DP = DIFFERENTIAL PAIR | TOOLING: | FINISH: | NOTES: | MATERIAL: | TESTING: | MISCELLANEOUS:
User.24: L2 GND | 08-      -07
User.25: L3 SIG | 08-      -08
User.26: L4 PWR | 08-      -09
User.27: L5 GND | 08-      -10
User.45: 98.0x31.0 | 138.0x31.0 | FIGURE | SIZE | 6.0 | 10.0 | 40.0 | 50.0 | 63.0 | 100.0 | 125.0 | PLATED | NON-PLATED | FINISHED HOLES IN MILS | ALL UNITS ARE IN MILS | QTY | 1 | 3 | 71 | 1025 | 13 | 2 | 5 | 4 | 1123 | TOLERANCE/NOTES | TOTAL HOLES:

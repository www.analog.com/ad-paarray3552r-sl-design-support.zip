# Allegro board AD-PAARRAY3552R-SL Allegro Project File.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
DFN8_2X3_PAD1_65X1_80
  oval 0.305x0.889 smd: 1(-0.75,-1.545) 2(-0.25,-1.545) 3(0.25,-1.545) 4(0.75,-1.545) 5(0.75,1.545) 6(0.25,1.545) 7(-0.25,1.545) 8(-0.75,1.545)
  rect 1.651x1.803 smd: PAD(0,0)
DFN8_3X3_PAD2_38X1_64
  oval 0.305x0.838 smd: 1(-0.75,-1.45) 2(-0.25,-1.45) 3(0.25,-1.45) 4(0.75,-1.45) 5(0.75,1.45) 6(0.25,1.45) 7(-0.25,1.45) 8(-0.75,1.45)
  rect 2.388x1.651 smd: PAD(0,0)
DFN8_3X3_PAD2_44X1_6_A
  oval 0.305x0.838 smd: 1(-0.75,-1.45) 2(-0.25,-1.45) 3(0.25,-1.45) 4(0.75,-1.45) 5(0.75,1.45) 6(0.25,1.45) 7(-0.25,1.45) 8(-0.75,1.45)
  rect 2.438x1.6 smd: PAD(0,0)
DFN12_3X3_PAD2_5X1_7
  oval 0.279x0.737 smd: 1(-1.25,-1.43) 2(-0.75,-1.43) 3(-0.25,-1.43) 4(0.25,-1.43) 5(0.75,-1.43) 6(1.25,-1.43) 7(1.25,1.43) 8(0.75,1.43) 9(0.25,1.43) 10(-0.25,1.43) 11(-0.75,1.43) 12(-1.25,1.43)
  rect 2.489x1.702 smd: PAD(0,0)
DFN16_4X3_PAD3_3X1_7
  oval 0.305x0.787 smd: 1(-1.575,-1.5) 2(-1.125,-1.5) 3(-0.675,-1.5) 4(-0.225,-1.5) 5(0.225,-1.5) 6(0.675,-1.5) 7(1.125,-1.5) 8(1.575,-1.5) 9(1.575,1.5) 10(1.125,1.5) 11(0.675,1.5) 12(0.225,1.5) 13(-0.225,1.5) 14(-0.675,1.5) 15(-1.125,1.5) 16(-1.575,1.5)
  rect 3.302x1.702 smd: PAD(0,0)
DO214AC
  rect 1.778x2.159 smd: A(2.032,0) C(-2.032,0)
IND-MSS1278
  rect 3.988x5.512 smd: 1(-4.242,0) 2(4.242,0)
JPRSLD03
  rect 0.61x1.524 smd: 1(-0.838,0) 2(0,0) 3(0.838,0)
L0805
  rect 1.194x1.448 smd: 1(-0.85,0) 2(0.85,0)
L0805_A
  rect 1.016x1.778 smd: 1(-0.889,0) 2(0.889,0)
L0806H39
  rect 0.787x1.6 smd: 1(-0.894,0) 2(0.894,0)
L1206
  rect 1.524x1.575 smd: 1(-1.714,0) 2(1.714,0)
LED0603
  rect 0.965x0.762 smd: A(0.8,0) C(-0.8,0)
LED0603-2
  rect 0.787x0.787 smd: A(0.787,0) C(-0.787,0)
LSMSQ189H161
  rect 2.007x5.309 smd: 1(-1.753,0) 2(1.753,0)
MSOP10_PAD1_88X1_68
  rect 0.305x1.143 smd: 1(-1,-2.106) 2(-0.5,-2.106) 3(0,-2.106) 4(0.5,-2.106) 5(1,-2.106) 6(1,2.106) 7(0.5,2.106) 8(0,2.106) 9(-0.5,2.106) 10(-1,2.106)
  rect 1.88x1.676 smd: PAD(0,0)
MSOP16_PAD2_845X1_651
  rect 0.305x1.448 smd: 1(-1.75,-2.15) 2(-1.25,-2.15) 3(-0.75,-2.15) 4(-0.25,-2.15) 5(0.25,-2.15) 6(0.75,-2.15) 7(1.25,-2.15) 8(1.75,-2.15) 9(1.75,2.15) 10(1.25,2.15) 11(0.75,2.15) 12(0.25,2.15) 13(-0.25,2.15) 14(-0.75,2.15) 15(-1.25,2.15) 16(-1.75,2.15)
  rect 2.845x1.651 smd: PAD(0,0)
NCSB
  custom 0.148x0.148 smd: 1(-0.383,0) 2(0.423,0)
QFN10_3X3_PAD2_38X1_64
  oval 0.254x0.813 smd: 1(-1,-1.5) 2(-0.5,-1.5) 3(0,-1.5) 4(0.5,-1.5) 5(1,-1.5) 6(1,1.5) 7(0.5,1.5) 8(0,1.5) 9(-0.5,1.5) 10(-1,1.5)
  rect 2.388x1.651 smd: PAD(0,0)
QFN32_5X5_PAD3_6X3_6
  oval 0.305x0.889 smd: 1(-1.75,-2.451) 2(-1.25,-2.451) 3(-0.75,-2.451) 4(-0.25,-2.451) 5(0.25,-2.451) 6(0.75,-2.451) 7(1.25,-2.451) 8(1.75,-2.451) 17(1.75,2.451) 18(1.25,2.451) 19(0.75,2.451) 20(0.25,2.451) 21(-0.25,2.451) 22(-0.75,2.451) 23(-1.25,2.451) 24(-1.75,2.451)
  oval 0.889x0.305 smd: 9(2.451,-1.75) 10(2.451,-1.25) 11(2.451,-0.75) 12(2.451,-0.25) 13(2.451,0.25) 14(2.451,0.75) 15(2.451,1.25) 16(2.451,1.75) 25(-2.451,1.75) 26(-2.451,1.25) 27(-2.451,0.75) 28(-2.451,0.25) 29(-2.451,-0.25) 30(-2.451,-0.75) 31(-2.451,-1.25) 32(-2.451,-1.75)
  rect 3.607x3.607 smd: PAD(0,0)
R0402
  rect 0.635x0.737 smd: 1(-0.5,0) 2(0.5,0)
R0603
  rect 0.787x0.991 smd: 1(-0.85,0) 2(0.85,0)
R0805
  rect 1.041x1.397 smd: 1(-0.95,0) 2(0.95,0)
R1210
  rect 1.575x2.692 smd: 1(-1.397,0) 2(1.397,0)
R1225H28
  rect 0.991x6.579 smd: 1(-1.595,0) 2(1.595,0)
R2512H35
  rect 2.108x3.988 smd: 1(-3.104,0) 2(3.104,0)
R2512H43
  rect 3.099x3.404 smd: 1(-2.649,0) 2(2.649,0)
SMC_A
  rect 1.524x3.073 smd: 1(-3.107,0) 2(3.107,0)
SO8
  rect 0.61x2.184 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SOD123F
  rect 1.194x1.194 smd: A(1.403,0) C(-1.403,0)
SON8
  rect 0.66x1.194 smd: 1(-1.92,-2.828) 2(-0.64,-2.828) 3(0.64,-2.828) 4(1.92,-2.828)
  custom 1.175x1.175 smd: 5(2,3.171)
  round 0.127 smd: 6(0.678,3.211) 7(-0.68,3.236) 8(-2.002,3.223)
SOT23-5L-2
  rect 0.61x1.194 smd: 1(-0.95,-1.15) 2(0,-1.15) 3(0.95,-1.15) 4(0.95,1.15) 5(-0.95,1.15)
SOT23_6
  rect 0.711x1.27 smd: 1(-0.953,-1.27) 2(0,-1.27) 3(0.953,-1.27) 4(0.953,1.27) 5(0,1.27) 6(-0.953,1.27)
SOT23_B
  rect 0.61x1.041 smd: 1(-0.958,-1.15) 2(0.958,-1.15) 3(0,1.15)
SSOP20-3
  rect 0.33x1.651 smd: 1(-2.857,-2.667) 2(-2.223,-2.667) 3(-1.587,-2.667) 4(-0.953,-2.667) 5(-0.318,-2.667) 6(0.318,-2.667) 7(0.953,-2.667) 8(1.587,-2.667) 9(2.223,-2.667) 10(2.857,-2.667) 11(2.857,2.667) 12(2.223,2.667) 13(1.587,2.667) 14(0.953,2.667) 15(0.318,2.667) 16(-0.318,2.667) 17(-0.953,2.667) 18(-1.587,2.667) 19(-2.223,2.667) 20(-2.857,2.667)
SWPANASONIC_EVQ
  rect 3.2x0.991 smd: 1(-3.4,-2) 2(3.4,-2) 3(-3.4,2) 4(3.4,2)
TPSMC30
  round 0.762 smd: 1(0,0)
unnamed
  round 4.445 hole 3.175 unplated: (0,0)
YSML98W79H26
  rect 1.194x0.991 smd: 1(-0.85,-0.65) 2(0.85,-0.65) 3(0.85,0.65) 4(-0.85,0.65)
YSML126W59H35
  rect 1.092x1.905 smd: 1(-1.246,0) 2(1.246,0)

## Nets
1V8: C50.1 C67.1 C68.1 C97.1 C98.1 C173.1 C174.1 R71.1 R72.1 R73.2(N2) R77.1 R79.1 R82.1 R83.1 R84.2(N2) R88.1 R90.1 R92.1 R133.1 R134.1 R135.2(N2) R139.1 R141.1 TP13.1(N1) U8.1 U8.2(VOUT2) U8.3 U12.1 U12.2 U16.1 U16.2 U26.1 U26.2
3V3: C49.1 C69.1 C70.1 C99.1 C100.1 C128.1 C129.1 C136.1 C139.1 C150.1 C175.1 C176.1 EN_DA.1(N1) P6.1 Q2.2(S) R18.2(N2) R40.2(N2) R97.1 R98.1 R99.1 R100.1 R105.2(N2) R108.2(N2) R129.2(N2) R171.1 R237.2(N2) TP12.1(N1) U7.1 U7.2(VOUT2) U7.3 U13.2 U17.2 U20.C7 U20.C11 U20.D9 U20.G10 U20.L2 U20.L10 U22.3(VCCIO) U27.2
5V0: C52.1 C61.1 C62.1 C66.1 C91.1 C92.1 C96.1 C155.1 C167.1 C168.1 C172.1 R58.1 R144.2(N2) TP14.1(N1) U9.2 U12.19 U16.19 U24.4(VCC) U26.19
5V0_849A: R58.2(N2) UNK5V_SW.1
5V0_5611: C35.1 R53.2(N2) TP9.1(N1) U4.9 U4.10 UNK5V_PDA.1
5V0_6201U: C36.1 R54.2(N2) TP10.1(N1) U5.9 U5.10 UNK5V_DA.1
5V0_G140: C31.1 R101.1 R102.1 R103.1 R107.2(N2) R109.1 TP8.1(N1) U3.1 U3.2(VOUT2) U3.3 U23.2 U23.15
5V0_VDC1: R103.2(N2) U23.1 VDC1.1(N1)
5V0_VDP1: R107.1 U23.16 VDP1.1(N1)
5V6: C24.1 C25.1 C26.1 C38.1 C39.1 C40.1 C41.1 C44.1 L2.2(N2) L3.1 L4.1 R43.2(N2) R44.2(N2) R57.1 R59.2(N2) R61.2(N2) R62.2(N2) R63.2(N2) TP11.1(N1) U3.7 U3.8 U4.1 U4.2 U5.1 U5.2 U7.5 U7.7 U7.8 U8.5 U8.7 U8.8 U9.7 U9.8 U10.8
48V0_7000_2: C27.1 R39.1 R47.1 TP6.1(N1) TP7.1(N1) U6.1(VIN)
48V0_G140: R17.1 R104.1 R106.1 R143.1 R145.2(N2) R147.1 TP3.1(N1) U30.2 U30.15
48V0_GTRB: R128.1 R148.1 R149.1 R150.1 R152.2(N2) R154.1 TP22.1(N1) U31.2 U31.15
48V0_VDC2: R143.2(N2) U30.1 VDC2.1(N1)
48V0_VDP2: R145.1 U30.16 VDP2.1(N1)
48V0_VIN: C2.2(N2) C4.2(N2) C5.2(N2) C6.2(N2) C13.2(N2) C14.2(N2) C15.2(N2) C16.2(N2) C156.2(N2) C157.2(N2) C158.2(N2) C159.2(N2) D1.2(C) R2.2(N2) R3.1 R7.2(N2) R9.1 R22.2(N2) R24.1 R29.2(N2) R31.1 R113.2(N2) R114.1 R118.2(N2) R120.1 TP1.1(N1) TP4.1(N1) TP20.1(N1)
+12V0: A1.7 A2.7 A3.7 A4.7 A5.7 A6.7 C56.2(N2) C59.1 C77.1 C79.1 C82.1 C84.1 C89.1 C90.1 C107.1 C109.1 C112.1 C114.1 C119.1 C120.1 C183.1 C185.1 C188.1 C190.1 C195.1 C196.1 D4.C R66.2(N2) TP15.1(N1) U14.4 U15.4 U18.4 U19.4 U28.4 U29.4
-12V0: A1.4 A2.4 A3.4 A4.4 A5.4 A6.4 C57.1 C58.1 C76.1 C78.1 C81.1 C83.1 C87.1 C88.1 C106.1 C108.1 C111.1 C113.1 C117.1 C118.1 C182.1 C184.1 C187.1 C189.1 C193.1 C194.1 L5.2(N2) R65.1 TP16.1(N1) U14.7 U14.PAD(VSS2) U15.7 U15.PAD(VSS2) U18.7 U18.PAD(VSS2) U19.7 U19.PAD(VSS2) U28.7 U28.PAD(VSS2) U29.7 U29.PAD(VSS2)
GND: C1.1 C3.2(N2) C4.1 C5.1 C6.1 C7.2(N2) C10.2(N2) C11.2(N2) C12.2(N2) C14.1 C15.1 C16.1 C17.2(N2) C18.2(N2) C21.2(N2) C22.2(N2) C23.2(N2) C24.2(N2) C25.2(N2) C26.2(N2) C27.2(N2) C28.2(N2) C29.2(N2) C30.2(N2) C31.2(N2) C32.2(N2) C33.2(N2) C35.2(N2) C36.2(N2) C37.1 C38.2(N2) C39.2(N2) C40.2(N2) C41.2(N2) C42.2(N2) C43.1 C44.2(N2) C45.2(N2) C46.2(N2) C47.2(N2) C48.1 C49.2(N2) C50.2(N2) C51.2(N2) C52.2(N2) C54.2(N2) C55.2(N2) C58.2(N2) C59.2(N2) C60.2(N2) C63.1 C64.1 C65.1 C66.2(N2) C67.2(N2) C68.2(N2) C69.2(N2) C70.2(N2) C72.1 C74.1 C75.2(N2) C76.2(N2) C77.2(N2) C78.2(N2) C79.2(N2) C80.2(N2) C81.2(N2) C82.2(N2) C83.2(N2) C84.2(N2) C85.1 C86.1 C87.2(N2) C88.2(N2) C89.2(N2) C90.2(N2) C93.1 C94.1 C95.1 C96.2(N2) C97.2(N2) C98.2(N2) C99.2(N2) C100.2(N2) C102.1 C104.1 C105.2(N2) C106.2(N2) C107.2(N2) C108.2(N2) C109.2(N2) C110.2(N2) C111.2(N2) C112.2(N2) C113.2(N2) C114.2(N2) C115.1 C116.1 C117.2(N2) C118.2(N2) C119.2(N2) C120.2(N2) C121.2(N2) C122.2(N2) C123.2(N2) C124.2(N2) C125.2(N2) C126.2(N2) C127.2(N2) C128.2(N2) C129.2(N2) C130.2(N2) C131.1 C132.2(N2) C133.2(N2) C134.1 C136.2(N2) C137.2(N2) C138.2(N2) C139.2(N2) C140.2(N2) C141.1 C142.1 C143.2(N2) C144.2(N2) C145.2(N2) C146.2(N2) C147.2(N2) C148.2(N2) C149.2(N2) C150.2(N2) C151.2(N2) C152.2(N2) C153.2(N2) C154.2(N2) C155.2(N2) C157.1 C158.1 C159.1 C160.2(N2) C161.2(N2) C164.2(N2) C165.2(N2) C166.2(N2) C169.1 C170.1 C171.1 C172.2(N2) C173.2(N2) C174.2(N2) C175.2(N2) C176.2(N2) C178.1 C180.1 C181.2(N2) C182.2(N2) C183.2(N2) C184.2(N2) C185.2(N2) C186.2(N2) C187.2(N2) C188.2(N2) C189.2(N2) C190.2(N2) C191.1 C192.1 C193.2(N2) C194.2(N2) C195.2(N2) C196.2(N2) C197.2(N2) C198.2(N2) C199.2(N2) C200.2(N2) C201.2(N2) C202.2(N2) C203.2(N2) C204.2(N2) C205.2(N2) C206.2(N2) C207.2(N2) C208.2(N2) C209.1 C210.1 C211.1 C212.1 D2.A(P) D3.A(P) D5.C D8.A(P) DS1.C DS3.C E1.2(N2) GND1.1(N1) GND2.1(N1) GND3.1(N1) GND4.1(N1) JP5.3 JP6.3 JP9.3 JP10.3 JP11.3 JP12.3 P1.2 P1.3(N3) P2.2(N2) P5.5 P6.3 P6.5 P6.9(N9) Q4.2(S) R1.1 R4.2(N2) R5.2(N2) R6.2(N2) R12.2(N2) R21.1 R23.2(N2) R25.2(N2) R27.2(N2) R28.2(N2) R34.2(N2) R41.2(N2) R42.2(N2) R45.1 R46.1 R49.1 R50.1 R51.1 R52.1 R55.1 R56.1 R60.1 R67.1 R68.2(N2) R69.2(N2) R70.1 R81.1 R93.2(N2) R94.2(N2) R110.2(N2) R112.1 R115.2(N2) R116.2(N2) R117.2(N2) R123.2(N2) R130.2(N2) R131.2(N2) R132.1 R146.1 R155.2(N2) R157.2(N2) R159.2(N2) R160.2(N2) R161.2(N2) R162.2(N2) R163.2(N2) R164.2(N2) R165.2(N2) R166.2(N2) R167.2(N2) R172.2(N2) R173.2(N2) R175.1 R176.1 R179.1 U1.PAD U2.PAD U3.6 U3.PAD U4.8 U4.PAD U5.8 U5.PAD U6.8 U6.12 U6.PAD U7.6 U7.PAD U8.6 U8.PAD U9.4 U9.PAD U10.5 U10.PAD U12.22 U12.30 U12.PAD U13.4 U14.3 U15.3 U16.22 U16.30 U16.PAD U17.4 U18.3 U19.3 U20.A1 U20.A7 U20.A11 U20.B1 U20.B3 U20.B7 U20.B10 U20.C1 U20.C2 U20.C4 U20.D4 U20.E2 U20.E3 U20.E4 U20.E10 U20.E11 U20.F7 U20.F8 U20.F9 U20.F10 U20.G1 U20.G2 U20.G3 U20.H11 U20.L5 U21.2 U22.6 U22.16 U23.12 U23.PAD U24.2 U25.PAD U26.22 U26.30 U26.PAD U27.4 U28.3 U29.3 U30.12 U30.PAD U31.12 U31.PAD Y1.2 Y1.4
PGND: E1.1 P5.G1 P5.G2 P5.G3 P5.G4(N9) P5.G5 P5.G6 R94.1
VCC_2992: C152.1 JP5.1 JP6.1 U23.7
VCC_2992_1: C200.1 JP9.1 JP10.1 U30.7
VCC_2992_2: C204.1 JP11.1 JP12.1 U31.7
VCC_7000_1: C12.1 R16.2(N2) R174.1 U1.3
VCC_7000_2: C23.1 R30.1 R38.2(N2) U2.3
VCC_7000_3: C166.1 R127.2(N2) R178.1 U25.3
32KIN_32666: C122.1 U20.F1 Y2.1
32KOUT_32666: C123.1 U20.F2 Y2.2(N2)
ADR0_2992: JP5.2(COM) U23.6
ADR0_2992_1: JP9.2(COM) U30.6
ADR0_2992_2: JP11.2(COM) U31.6
ADR1_2992: JP6.2(COM) U23.5
ADR1_2992_1: JP10.2(COM) U30.5
ADR1_2992_2: JP12.2(COM) U31.5
ALERT_N: R73.1 U12.11
ALERT_N_1: R84.1 U16.11
ALERT_N_2: R135.1 U26.11
DAC_REF_3552R_0: C80.1 P3.2(N2) U12.20(VREF)
DAC_REF_3552R_1: C110.1 P4.2(N2) U16.20(VREF)
DAC_REF_3552R_2: C186.1 P11.2(N2) U26.20(VREF)
DM_32666: R96.2(N2) R205.2(N2) U22.12
DP_32666: R95.2(N2) R204.2(N2) U22.11
HFXIN_32666: C121.1 U20.A4 Y1.1
HFXOUT_32666: C124.1 U20.B4 Y1.3(N2)
IOUT0_3552R: A1.2 C71.2(N2) U12.26
IOUT0_3552R_1: A3.2 C101.2(N2) U16.26
IOUT0_3552R_2: A5.2 C177.2(N2) U26.26
IOUT1_3552R: A2.2 C73.2(N2) U12.15
IOUT1_3552R_1: A4.2 C103.2(N2) U16.15
IOUT1_3552R_2: A6.2 C179.2(N2) U26.15
P0_0_UART2_CTS: P8.2(N2) R181.1
P0_1_UART2_TX: P6.6 P9.2(N2) R182.1
P0_2_UART2_RX: P6.8 P10.2(N2) R192.1
P0_3_UART2_RTS: P7.2(N2) R206.2(N2)
P0_4_GPIO_FAULT: R209.2(N2) R236.2(N2)
P0_5_GPIO_FAULT: R40.1 R210.2(N2) U2.5
P0_6_I2C0_SCL: R105.1 R211.2(N2) U23.9 U30.9 U31.9
P0_7_I2C0_SDA: R108.1 R212.2(N2) U23.10 U23.11 U30.10 U30.11 U31.10 U31.11
P0_12_GPIO_LDAC0: R71.2(N2) R185.1 U12.9
P0_13_GPIO_LDAC1: R82.2(N2) R186.1 U16.9
P0_14_GPIO_FAULT_LED: R19.1 R187.1
P0_16_AIN0_MON: R41.1 R77.2(N2) R78.1 R188.1
P0_17_AIN1_MON: R42.1 R79.2(N2) R80.1 R189.1
P0_18_AIN2_MON: R68.1 R88.2(N2) R89.1 R190.1
P0_19_AIN3_MON: R69.1 R90.2(N2) R91.1 R191.1
P0_20_AIN4_MON: R130.1 R139.2(N2) R140.1 R193.1
P0_21_AIN5_MON: R131.1 R141.2(N2) R142.1 R194.1
P0_22_AIN6_MON: R110.1 R111.2(N2) R195.1
P0_23_GPIO_LDAC2: R133.2(N2) R196.1 U26.9
P0_24_QSPI2_SS0: R197.1 U12.3
P0_25_QSPI2_MOSI: R198.1 U12.5 U16.5 U26.5
P0_26_QSPI2_MISO: R199.1 U12.6 U16.6 U26.6
P0_27_QSPI2_SCK: R200.1 U12.4 U16.4 U26.4
P0_28_GPIO_EN: EN_SW.1(N1) R167.1 R201.1
P0_30_QSPI2_SS1: R207.2(N2) U16.3
P0_31_QSPI2_SS2: R208.2(N2) U26.3
P1_0_GPIO_FAULT: R18.1 R215.2(N2) U1.5
P1_1_GPIO_INP: R119.1 R216.2(N2)
P1_2_GPIO_FAULT: R129.1 R223.2(N2) U25.5
P1_3_GPIO_EN: R158.1 R224.2(N2)
P1_4_GPIO_EN: R157.1 R225.2(N2) U5.3
P1_5_GPIO_EN: R155.1 R226.2(N2) U4.3
P1_6_GPIO_RESET: R72.2(N2) R83.2(N2) R134.2(N2) R227.2(N2) U12.10 U16.10 U26.10
P1_7_GPIO_IN: R161.1 R228.2(N2) U14.6
P1_8_GPIO_INP: R8.1 R229.2(N2)
P1_9_GPIO_IN: R162.1 R230.2(N2) U15.6
P1_10_GPIO_IN: R163.1 R217.2(N2) U18.6
P1_11_GPIO_IN: R164.1 R218.2(N2) U19.6
P1_12_GPIO_IN: R165.1 R219.2(N2) U28.6
P1_13_GPIO_IN: R166.1 R220.2(N2) U29.6
QSPI_3552R: R70.2(N2) U12.31
QSPI_3552R_1: R81.2(N2) U16.31
QSPI_3552R_2: R132.2(N2) U26.31
RFB0_X1_3552R: JP2.1 U12.25
RFB0_X1_3552R_1: JP4.1 U16.25
RFB0_X1_3552R_2: JP8.1 U26.25
RFB0_X2_3552R: JP2.2(COM) U12.24
RFB0_X2_3552R_1: JP4.2(COM) U16.24
RFB0_X2_3552R_2: JP8.2(COM) U26.24
RFB0_X4_3552R: A1.6(VOUT) C71.1 JP2.3 R75.1 U12.23
RFB0_X4_3552R_1: A3.6(VOUT) C101.1 JP4.3 R86.1 U16.23
RFB0_X4_3552R_2: A5.6(VOUT) C177.1 JP8.3 R137.1 U26.23
RFB1_X1_3552R: JP1.1 U12.16
RFB1_X1_3552R_1: JP3.1 U16.16
RFB1_X1_3552R_2: JP7.1 U26.16
RFB1_X2_3552R: JP1.2(COM) U12.17
RFB1_X2_3552R_1: JP3.2(COM) U16.17
RFB1_X2_3552R_2: JP7.2(COM) U26.17
RFB1_X4_3552R: A2.6(VOUT) C73.1 JP1.3 R76.1 U12.18
RFB1_X4_3552R_1: A4.6(VOUT) C103.1 JP3.3 R87.1 U16.18
RFB1_X4_3552R_2: A6.6(VOUT) C179.1 JP7.3 R138.1 U26.18
RSTN_32666: P6.10 R92.2(N2) R180.1 S3.3
SWDCLK_32666: P6.4 R173.1 R203.2(N2)
SWDIO_32666: P6.2 R171.2(N2) R202.2(N2)
UNNAMED_5_ADM7150_I112_BYP: C42.1 U9.3
UNNAMED_5_ADM7150_I112_REF: C51.1 U9.5 U9.6
UNNAMED_5_ADM7150_I112_VREG: C45.1 U9.1(VREG)
UNNAMED_5_ADM7170_I67_SS: C46.1 U7.4
UNNAMED_5_ADM7170_I73_SS: C47.1 U8.4
UNNAMED_5_ADM7172_I160_EN: R158.2(N2) R159.1 U3.5
UNNAMED_5_ADM7172_I160_SS: C30.1 U3.4
UNNAMED_5_ADMAX17643_I170_BST: C34.2(N2) U6.10
UNNAMED_5_ADMAX17643_I170_EN: R47.2(N2) U6.2
UNNAMED_5_ADMAX17643_I170_EXTVCC: C37.2(N2) R52.2(N2) R57.2(N2) U6.9
UNNAMED_5_ADMAX17643_I170_FB: R59.1 R60.2(N2) U6.7
UNNAMED_5_ADMAX17643_I170_LX: C34.1 L2.1 U6.11
UNNAMED_5_ADMAX17643_I170_RESETN: R48.2(N2) U6.3
UNNAMED_5_ADMAX17643_I170_RT: R49.2(N2) U6.6
UNNAMED_5_ADMAX17643_I170_SS: C28.1 U6.4
UNNAMED_5_ADMAX17643_I170_VCC: C29.1 R48.1 U6.5
UNNAMED_5_CAP_I20_N1: C32.1 R50.2(N2) U4.7(SET)
UNNAMED_5_CAP_I21_N1: C33.1 R51.2(N2) U5.7(SET)
UNNAMED_5_CAP_I88_N2: C43.2(N2) R62.1 U10.9
UNNAMED_5_CAP_I90_N2: C48.2(N2) R63.1 U10.7
UNNAMED_5_CAP_I118_N1: C53.1 D5.A(P) L5.1
UNNAMED_5_CAP_I118_N2: C53.2(N2) L4.2(N2) U10.6
UNNAMED_5_CAP_I130_N2: C57.2(N2) R64.1 R65.2(N2) U10.4
UNNAMED_5_CAP_I142_N1: C55.1 R64.2(N2) U10.2 U10.3(VREF)
UNNAMED_5_CAP_I143_N1: C56.1 R66.1 R67.2(N2) U10.1
UNNAMED_5_DIOLED_I85_P: DS3.A(P) R61.1
UNNAMED_5_DIOSCHOTTKY_I144_P: D4.A(P) L3.2(N2) U10.10
UNNAMED_5_LINLT3042_I14_ILIM: R45.2(N2) U4.5
UNNAMED_5_LINLT3042_I14_PG: R43.1 U4.4
UNNAMED_5_LINLT3042_I14_PGFB: R53.1 R55.2(N2) U4.6
UNNAMED_5_LINLT3042_I17_ILIM: R46.2(N2) U5.5
UNNAMED_5_LINLT3042_I17_PG: R44.1 U5.4
UNNAMED_5_LINLT3042_I17_PGFB: R54.1 R56.2(N2) U5.6
UNNAMED_6_AD3552R_I19_CVREF: C65.2(N2) U12.21
UNNAMED_6_AD3552R_I19_NCAP0: C63.2(N2) U12.28
UNNAMED_6_AD3552R_I19_NCAP1: C64.2(N2) U12.13
UNNAMED_6_AD3552R_I19_PCAP0: C61.2(N2) U12.29
UNNAMED_6_AD3552R_I19_PCAP1: C62.2(N2) U12.12
UNNAMED_6_ADG1401_I69_D: C85.2(N2) R75.2(N2) R78.2(N2) U14.8
UNNAMED_6_ADG1401_I72_D: C86.2(N2) R76.2(N2) R80.2(N2) U15.8
UNNAMED_6_ADR45XX_I7_VOUT: C75.1 R74.1 U13.6(VOUT)
UNNAMED_6_NC2P_I13_N1: P3.1 R74.2(N2)
UNNAMED_7_AD3552R_I13_CVREF: C95.2(N2) U16.21
UNNAMED_7_AD3552R_I13_NCAP0: C93.2(N2) U16.28
UNNAMED_7_AD3552R_I13_NCAP1: C94.2(N2) U16.13
UNNAMED_7_AD3552R_I13_PCAP0: C91.2(N2) U16.29
UNNAMED_7_AD3552R_I13_PCAP1: C92.2(N2) U16.12
UNNAMED_7_ADG1401_I52_D: C116.2(N2) R87.2(N2) R91.2(N2) U19.8
UNNAMED_7_ADG1401_I59_D: C115.2(N2) R86.2(N2) R89.2(N2) U18.8
UNNAMED_7_ADR45XX_I83_VOUT: C105.1 R85.1 U17.6(VOUT)
UNNAMED_7_NC2P_I73_N1: P4.1 R85.2(N2)
UNNAMED_14_AD3552R_I75_CVREF: C171.2(N2) U26.21
UNNAMED_14_AD3552R_I75_NCAP0: C169.2(N2) U26.28
UNNAMED_14_AD3552R_I75_NCAP1: C170.2(N2) U26.13
UNNAMED_14_AD3552R_I75_PCAP0: C167.2(N2) U26.29
UNNAMED_14_AD3552R_I75_PCAP1: C168.2(N2) U26.12
UNNAMED_14_ADG1401_I59_D: C192.2(N2) R138.2(N2) R142.2(N2) U29.8
UNNAMED_14_ADG1401_I68_D: C191.2(N2) R137.2(N2) R140.2(N2) U28.8
UNNAMED_14_ADR45XX_I81_VOUT: C181.1 R136.1 U27.6(VOUT)
UNNAMED_14_NC2P_I28_N1: P11.1 R136.2(N2)
UNNAMED_16_ADLTC7000_I34_BST: C9.1 R16.1 U1.14
UNNAMED_16_ADLTC7000_I34_IMON: C11.1 U1.10
UNNAMED_16_ADLTC7000_I34_INP: R8.2(N2) R174.2(N2) R175.2(N2) U1.7
UNNAMED_16_ADLTC7000_I34_ISET: R12.1 U1.9
UNNAMED_16_ADLTC7000_I34_OVLO: R3.2(N2) R4.1 U1.8
UNNAMED_16_ADLTC7000_I34_RUN: R156.2(N2) R172.1 U1.1
UNNAMED_16_ADLTC7000_I34_SNS: C8.1 R10.2(N2) U1.15
UNNAMED_16_ADLTC7000_I34_SNS_1: C8.2(N2) R7.1 U1.16
UNNAMED_16_ADLTC7000_I34_TGDN: R13.2(N2) U1.11
UNNAMED_16_ADLTC7000_I34_TGUP: R11.2(N2) U1.12
UNNAMED_16_ADLTC7000_I34_TIMER: C7.1 R6.1 TP2.1(N1) U1.6
UNNAMED_16_ADLTC7000_I34_TS: C9.2(N2) D2.C Q1.1 Q1.2 Q1.3(S3) R17.2(N2) U1.13
UNNAMED_16_ADLTC7000_I34_VCCUV: R5.1 U1.4
UNNAMED_16_ADLTC7000_I34_VIN: C3.1 R2.1 R156.1 U1.2(VIN)
UNNAMED_16_CAP_I12_N1: C2.1 R1.2(N2)
UNNAMED_16_CAP_I47_N1: C10.1 R14.1
UNNAMED_16_CAP_I68_N2: C1.2(N2) D1.1 L1.2(N2)
UNNAMED_16_CN2P_I62_N1: L1.1 P1.1 P2.1
UNNAMED_16_DIOLED_I54_P: DS1.A(P) R20.1
UNNAMED_16_RES_I38_N2: Q1.5 Q1.6 Q1.7 Q1.8 R9.2(N2) R10.1
UNNAMED_16_RES_I60_N2: Q2.3 R20.2(N2)
UNNAMED_16_RES_I76_N2: Q2.1 R19.2(N2)
UNNAMED_16_RES_I77_N2: R11.1 R13.1 R14.2(N2) R15.1
UNNAMED_16_RES_I80_N2: Q1.4 R15.2(N2)
UNNAMED_17_ADLTC7000_I28_BST: C20.1 R38.1 U2.14
UNNAMED_17_ADLTC7000_I28_IMON: C22.1 U2.10
UNNAMED_17_ADLTC7000_I28_INP: R30.2(N2) R176.2(N2) U2.7
UNNAMED_17_ADLTC7000_I28_ISET: R34.1 U2.9
UNNAMED_17_ADLTC7000_I28_OVLO: R24.2(N2) R25.1 U2.8
UNNAMED_17_ADLTC7000_I28_RUN: R23.1 R26.1 U2.1
UNNAMED_17_ADLTC7000_I28_SNS: C19.1 R32.2(N2) U2.15
UNNAMED_17_ADLTC7000_I28_SNS_1: C19.2(N2) R29.1 U2.16
UNNAMED_17_ADLTC7000_I28_TGDN: R35.2(N2) U2.11
UNNAMED_17_ADLTC7000_I28_TGUP: R33.2(N2) U2.12
UNNAMED_17_ADLTC7000_I28_TIMER: C18.1 R28.1 TP5.1(N1) U2.6
UNNAMED_17_ADLTC7000_I28_TS: C20.2(N2) D3.C Q3.1 Q3.2 Q3.3(S3) R39.2(N2) U2.13
UNNAMED_17_ADLTC7000_I28_VCCUV: R27.1 U2.4
UNNAMED_17_ADLTC7000_I28_VIN: C17.1 R22.1 R26.2(N2) U2.2(VIN)
UNNAMED_17_CAP_I4_N1: C13.1 R21.2(N2)
UNNAMED_17_CAP_I41_N1: C21.1 R36.1
UNNAMED_17_RES_I37_N1: Q3.5 Q3.6 Q3.7 Q3.8 R31.2(N2) R32.1
UNNAMED_17_RES_I39_N2: R33.1 R35.1 R36.2(N2) R37.2(N2)
UNNAMED_17_RES_I40_N1: Q3.4 R37.1
UNNAMED_18_ADLTC7000_I30_BST: C163.1 R127.1 U25.14
UNNAMED_18_ADLTC7000_I30_IMON: C165.1 U25.10
UNNAMED_18_ADLTC7000_I30_INP: R119.2(N2) R178.2(N2) R179.2(N2) U25.7
UNNAMED_18_ADLTC7000_I30_ISET: R123.1 U25.9
UNNAMED_18_ADLTC7000_I30_OVLO: R114.2(N2) R115.1 U25.8
UNNAMED_18_ADLTC7000_I30_RUN: R160.1 R177.2(N2) U25.1
UNNAMED_18_ADLTC7000_I30_SNS: C162.1 R121.2(N2) U25.15
UNNAMED_18_ADLTC7000_I30_SNS_1: C162.2(N2) R118.1 U25.16
UNNAMED_18_ADLTC7000_I30_TGDN: R124.2(N2) U25.11
UNNAMED_18_ADLTC7000_I30_TGUP: R122.2(N2) U25.12
UNNAMED_18_ADLTC7000_I30_TIMER: C161.1 R117.1 TP21.1(N1) U25.6
UNNAMED_18_ADLTC7000_I30_TS: C163.2(N2) D8.C Q5.1 Q5.2 Q5.3(S3) R128.2(N2) U25.13
UNNAMED_18_ADLTC7000_I30_VCCUV: R116.1 U25.4
UNNAMED_18_ADLTC7000_I30_VIN: C160.1 R113.1 R177.1 U25.2(VIN)
UNNAMED_18_CAP_I4_N1: C156.1 R112.2(N2)
UNNAMED_18_CAP_I42_N1: C164.1 R125.2(N2)
UNNAMED_18_RES_I38_N1: Q5.5 Q5.6 Q5.7 Q5.8 R120.2(N2) R121.1
UNNAMED_18_RES_I66_N1: R122.1 R124.1 R125.1 R126.1
UNNAMED_18_RES_I69_N2: Q5.4 R126.2(N2)
UNNAMED_19_ADMAX32666_I33_DM: R205.1 U20.F11
UNNAMED_19_ADMAX32666_I33_DP: R204.1 U20.G11
UNNAMED_19_ADMAX32666_I33_LXA: L6.2(N2) U20.B11
UNNAMED_19_ADMAX32666_I33_LXB: C135.1 L6.1 U20.A10
UNNAMED_19_ADMAX32666_I33_P0: R191.2(N2) U20.J11
UNNAMED_19_ADMAX32666_I33_P0_1: R194.2(N2) U20.E8
UNNAMED_19_ADMAX32666_I33_P0_2: R200.2(N2) U20.H7
UNNAMED_19_ADMAX32666_I33_P0_3: R201.2(N2) U20.J7
UNNAMED_19_ADMAX32666_I33_P0_4: R197.2(N2) U20.G8
UNNAMED_19_ADMAX32666_I33_P0_7: R185.2(N2) U20.G5
UNNAMED_19_ADMAX32666_I33_P0_8: R186.2(N2) U20.H5
UNNAMED_19_ADMAX32666_I33_P0_9: R187.2(N2) U20.F5
UNNAMED_19_ADMAX32666_I33_P0_11: R188.2(N2) U20.K11
UNNAMED_19_ADMAX32666_I33_P0_12: R190.2(N2) U20.G9
UNNAMED_19_ADMAX32666_I33_P0_13: R192.2(N2) U20.J10
UNNAMED_19_ADMAX32666_I33_P0_14: R193.2(N2) U20.H10
UNNAMED_19_ADMAX32666_I33_P0_15: R195.2(N2) U20.E9
UNNAMED_19_ADMAX32666_I33_P0_16: R196.2(N2) U20.D8
UNNAMED_19_ADMAX32666_I33_P0_17: R198.2(N2) U20.H8
UNNAMED_19_ADMAX32666_I33_P0_18: R199.2(N2) U20.J8
UNNAMED_19_ADMAX32666_I33_P0_19: R210.1 U20.L9
UNNAMED_19_ADMAX32666_I33_P0_20: R211.1 U20.L8
UNNAMED_19_ADMAX32666_I33_P0_21: R209.1 U20.K9
UNNAMED_19_ADMAX32666_I33_P0_22: R212.1 U20.K8
UNNAMED_19_ADMAX32666_I33_P0_23: R182.2(N2) U20.K7
UNNAMED_19_ADMAX32666_I33_P0_24: R181.2(N2) U20.K6
UNNAMED_19_ADMAX32666_I33_P0_25: R208.1 U20.K5
UNNAMED_19_ADMAX32666_I33_P0_26: R206.1 U20.J9
UNNAMED_19_ADMAX32666_I33_P0_27: R207.1 U20.J6
UNNAMED_19_ADMAX32666_I33_P0_28: R189.2(N2) U20.H9
UNNAMED_19_ADMAX32666_I33_P1: R223.1 U20.L4
UNNAMED_19_ADMAX32666_I33_P1_1: R224.1 U20.K4
UNNAMED_19_ADMAX32666_I33_P1_2: R216.1 U20.K3
UNNAMED_19_ADMAX32666_I33_P1_3: R215.1 U20.K2
UNNAMED_19_ADMAX32666_I33_P1_4: R225.1 U20.J5
UNNAMED_19_ADMAX32666_I33_P1_5: R226.1 U20.J4
UNNAMED_19_ADMAX32666_I33_P1_6: R227.1 U20.J3
UNNAMED_19_ADMAX32666_I33_P1_7: R228.1 U20.J2
UNNAMED_19_ADMAX32666_I33_P1_8: R229.1 U20.H4
UNNAMED_19_ADMAX32666_I33_P1_9: R217.1 U20.H3
UNNAMED_19_ADMAX32666_I33_P1_10: R218.1 U20.H2
UNNAMED_19_ADMAX32666_I33_P1_11: R230.1 U20.H1
UNNAMED_19_ADMAX32666_I33_P1_13: R220.1 U20.E6
UNNAMED_19_ADMAX32666_I33_P1_14: R219.1 U20.E5
UNNAMED_19_ADMAX32666_I33_RSTN: R180.2(N2) U20.C5
UNNAMED_19_ADMAX32666_I33_SWCLK: R203.1 U20.G7
UNNAMED_19_ADMAX32666_I33_SWDIO: R202.1 U20.C6
UNNAMED_19_ADMAX32666_I33_VBST: C135.2(N2) U20.C10
UNNAMED_19_RES_I17_N1: R93.1 S3.1
UNNAMED_20_ADMAX3207E_I10_I: C145.1 P5.2 R96.1 U21.4 U21.6(NC_2)
UNNAMED_20_ADMAX3207E_I10_I_1: C144.1 P5.3 R95.1 U21.1 U21.3
UNNAMED_20_ADMAX3207E_I10_VCC: C143.1 L7.1 P5.1 U21.5
UNNAMED_20_CAP_I32_N1: C149.1 U22.13
UNNAMED_20_CAP_I35_N1: C146.1 C147.1 C148.1 L7.2(N2) U22.15
UNNAMED_20_ICFT231XS_I38_CTS: P7.1 R97.2(N2) U22.9
UNNAMED_20_ICFT231XS_I38_RTS: P8.1 R100.2(N2) U22.2
UNNAMED_20_ICFT231XS_I38_RXD: P9.1 R98.2(N2) U22.4
UNNAMED_20_ICFT231XS_I38_TXD: P10.1 R99.2(N2) U22.20
UNNAMED_21_ADLTC2992_I16_VDD: C153.1 R102.2(N2) U23.8(VDD)
UNNAMED_21_ADLTC2992_I48_VDD: C201.1 R106.2(N2) U30.8(VDD)
UNNAMED_21_CAP_I7_N1: C151.1 R101.2(N2)
UNNAMED_21_CAP_I23_N1: C154.1 R109.2(N2)
UNNAMED_21_CAP_I35_N1: C199.1 R104.2(N2)
UNNAMED_21_CAP_I45_N1: C202.1 R147.2(N2)
UNNAMED_22_ADLTC2992_I24_VDD: C205.1 R149.2(N2) U31.8(VDD)
UNNAMED_22_CAP_I27_N1: C206.1 R154.2(N2)
UNNAMED_22_CAP_I36_N1: C203.1 R148.2(N2)
UNNAMED_23_ADMAX6516_I1_HYST: R144.1 R146.2(N2) U24.3
UNNAMED_23_ADMAX6516_I1_OUT: R111.1 U24.1
UNNAMED_23_ADMAX6516_I1_TOVER: Q4.1 U24.5
UNNAMED_23_DIOLED_I12_N: DS2.C Q4.3 R236.1
UNNAMED_23_DIOLED_I12_P: DS2.A(P) R237.1
VCM0_3552R: A1.3 C72.2(N2) U12.27
VCM0_3552R_1: A3.3 C102.2(N2) U16.27
VCM0_3552R_2: A5.3 C178.2(N2) U26.27
VCM1_3552R: A2.3 C74.2(N2) U12.14
VCM1_3552R_1: A4.3 C104.2(N2) U16.14
VCM1_3552R_2: A6.3 C180.2(N2) U26.14
VD1: R150.2(N2) U31.1 VD1.1(N1)
VD2: R152.1 U31.16 VD2.1(N1)
VG1: C197.1 U28.1 VG1.1(N1)
VG2: C198.1 U29.1 VG2.1(N1)
VGC1: C207.1 U18.1 VGC1.1(N1)
VGC2: C54.1 U14.1 VGC2.1(N1)
VGP1: C208.1 U19.1 VGP1.1(N1)
VGP2: C60.1 U15.1 VGP2.1(N1)
VREGO_A: C137.1 C140.1 C209.2(N2) U20.B9 U20.C8 U20.C9 U20.K10 U20.L3 U20.L11
VREGO_B: C130.1 C132.1 C133.1 C210.2(N2) U20.A9 U20.D11 U20.J1 U20.L7
VREGO_C: C125.1 C126.1 C127.1 C211.2(N2) U20.A8 U20.D10 U20.K1 U20.L6
VREGO_D: C131.2(N2) C134.2(N2) C212.2(N2) U20.A5 U20.A6 U20.B8
VRXOUT: C138.1 C142.2(N2) U20.A3 U20.B5 U20.D1 U20.D2 U20.D3 U20.E1
VTXOUT: C141.2(N2) U20.B6(VTXOUT) U20.C3

Pads without a net: A1 1 5 8; A2 1 5 8; A3 1 5 8; A4 1 5 8; A5 1 5 8; A6 1 5 8; P5 4; P6 7; S3 2 4; U12 7 8 32; U13 1 3 5 7 8; U14 2 5; U15 2 5; U16 7 8 32; U17 1 3 5 7 8; U18 2 5; U19 2 5; U20 A2 B2 D5 D6 D7 E7 F3 F4 F6 G4 G6 H6 L1; U22 1 5 7 8 10 14 17 18 19; U23 3 4 13 14; U26 7 8 32; U27 1 3 5 7 8; U28 2 5; U29 2 5; U30 3 4 13 14; U31 3 4 13 14

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 1025 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 71 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V8: length 97.5
  TOP w0.305: v1(29.44,48.84) C98.1 30.58,49.19 U16.2 ; 38.62,22.57 U8.1 39.6,23.14 39.57,23.16 ; v1(11.25,48.84) C173.1 12.04,49.33 12.29,49.58 13.16,49.58 13.46,49.89 U26.1 ; U16.1 30.08,49.89 29.77,49.58 28.91,49.58 28.65,49.33 C97.1 v1(27.86,48.84) ; U8.3 38.64,21.57 ; v1(46.05,48.84) C68.1 47.19,49.19 U12.2 ; U8.2 38.64,22.07 ; U26.2 13.96,49.19 C174.1 13.1,48.84 v1(12.83,48.56) ; v1(44.48,48.84) C67.1 45.26,49.33 45.52,49.58 46.38,49.58 46.69,49.89 U12.1
  TOP w0.508: R134.1 v1(21.92,48.92) ; R134.1 R133.1 ; R134.1 R135.2 ; R82.1 R83.1 ; R83.1 v1(38.53,48.92) ; R83.1 R84.2 ; R72.1 v1(55.14,48.92) ; R72.1 R71.1 ; R72.1 R73.2
  L3_SIG w0.508: v1(38.73,24.31) 41.99,24.31 42.8,25.12 48.26,25.12 49.07,24.31 51.26,24.31 51.61,23.95 51.61,23.34 52.07,22.89 54.76,22.89 62.66,14.99 64.34,14.99 68.45,10.87 68.45,9.07 68.96,8.56 76.23,8.56 76.94,9.27 76.94,11.02 77.88,11.96 84.18,11.96 88.13,8.01 v1(88.13,7.59)
  BOTTOM w0.508: R92.1 v1(88.13,7.59) ; R77.1 38.23,63.58 v1(38.2,63.6) ; v1(21.44,63.58) 21.46,63.55 R88.1 ; R90.1 31.78,63.55 v1(31.62,63.7) ; R79.1 v1(49.2,62.72) ; R141.1 16.08,62.62 v1(15.98,62.73) ; R139.1 v1(10.24,64.72)
  vias: v1(38.02,24.31) v1(38.02,23.6) v1(38.73,23.6)
3V3: length 118.6
  TOP w0.203: U20.G10 v2(29.16,29.87) ; U20.C11 v2(28.51,27.27) ; U20.L10 v2(29.16,33.12) ; U20.L2 v2(34.68,33.25) ; U20.D9 v2(29.81,27.92) ; U20.C7 v2(31.11,27.92)
  TOP w0.305: 47.79,22.57 U7.1 48.77,23.14 48.74,23.16 ; U7.2 47.81,22.07 ; U7.3 47.81,21.57
  TOP w0.508: v1(11.07,41.81) 11.07,42.13 R171.1 ; P6.1 v1(4.42,42.21)
  L3_SIG w0.508: v2(28.51,27.27) 27.99,27.78 27.99,28.88 28.98,29.87 v2(29.16,29.87) ; v1(94.74,32.08) 94.08,32.74 93.19,32.74 92.81,32.36 92.81,31.17 93.85,30.12 93.85,17.12 91.08,14.35 91.08,11.07 90.25,10.24 90.25,9.91 v1(90.02,9.68) 89.15,9.68 85.22,13.61 77.29,13.61 75.29,11.61 v1(75.29,10.13)
  L4_PWR w0.305: v2(34.68,33.25) 34.68,34.08 33.73,35.03 30.73,35.03 30.71,35.05 29.54,33.88 29.54,33.5 v2(29.16,33.12) 29.16,33.13 28.17,34.11
  L4_PWR w1.016: EN_DA.1 9.65,10.24
  BOTTOM w0.305: v2(29.16,33.12) 29.16,33.12 C139.1 ; C136.1 27.99,29.87 v2(29.16,29.87) ; C128.1 27.15,24.03 27.15,26.64 27.77,27.27 v2(28.51,27.27) 29.16,27.92 v2(29.81,27.92) 31.1,27.92 v2(31.11,27.92)
  BOTTOM w0.33: v1(23.71,32.49) C150.1 23.69,33.29 U22.3
  BOTTOM w0.381: R97.1 v1(24.1,28.48) ; R98.1 v1(24.1,30.72)
  BOTTOM w0.508: U13.2 30.28,42.82 C70.1 C69.1 v1(28.45,42.83) ; v1(11.38,35.1) 12.34,35.1 12.9,34.54 R99.1 ; U17.2 16.49,43.64 C99.1 C100.1 v1(15.47,42.82) ; R129.2 74.57,11.71 75.29,11 v1(75.29,10.13) ; R237.2 74.33,3.53 v1(76.28,3.53) Q2.2 ; v1(10.21,12.24) 9.47,12.24 9.23,12.49 R108.2 R105.2 ; v1(90.02,9.68) 89.53,9.68 89.19,9.33 R18.2 ; v1(94.74,32.08) 94.74,32.64 94.44,32.94 R40.2 ; R100.1 v1(23.27,36.14) ; v1(8.86,35.05) C175.1 C176.1 8.86,36.86 U27.2
  vias: v1(24.84,23.6) v1(25.55,23.6) v1(47.19,24.31) v1(47.19,23.6) v1(47.9,24.31) v1(47.9,23.6)
5V0: length 70.7
  TOP w0.305: U12.19 49.19,56.02 49.48,56.31 C66.1 ; U26.19 15.96,56.02 16.26,56.31 C172.1 ; U16.19 32.58,56.02 32.87,56.31 C96.1
  TOP w0.381: C96.1 33.36,56.83 33.66,57.12 v1(33.66,57.28) ; v1(17.04,57.28) 17.04,57.12 16.75,56.83 C172.1 ; v1(50.27,57.28) 50.27,57.12 49.97,56.83 C66.1
  TOP w0.508: v1(58.95,56.59) v1(58.95,57.3) 58.95,57.31 TP14.1 ; C167.1 v1(7.34,51.05) ; C91.1 24.18,51.05 23.94,51.3 v1(23.94,52.37) ; v1(40.55,52.37) 40.55,51.3 40.79,51.05 C61.1 ; v1(21.88,52.37) 21.88,51.27 21.64,51.03 C168.1 ; C92.1 38.25,51.03 38.49,51.27 v1(38.49,52.37) ; C62.1 54.86,51.03 55.11,51.27 v1(55.11,52.37) ; R144.2 v1(16.59,42.14) ; U24.4 24.17,42.88 C155.1 v1(26.47,42.88)
  L3_SIG w0.508: v1(26.47,42.88) 25.72,42.14 20.29,42.14 19.98,41.82 16.9,41.82 v1(16.59,42.14) 16.81,42.14 17.14,42.47 17.14,43.21 16.74,43.61 14.33,43.61 12.09,45.85 12.09,53.47 13.92,55.3 15.6,55.3 17.04,56.74 v1(17.04,57.28)
  BOTTOM w0.305: U9.2 59.44,55.28 C52.1
  BOTTOM w0.381: C52.1 v1(58.95,56.59)
  BOTTOM w0.508: v1(7.34,51.05) 7.06,50.77 R58.1
  BOTTOM w0.635: R58.1 5.76,55.85 7.8,57.89 v1(8.74,57.89) v1(8.74,58.67)
5V0_849A: length 2.2
  BOTTOM w0.635: R58.2 2.57,50.77 UNK5V_SW.1
5V0_5611: length 13.9
  TOP w0.305: 63.98,58.75 63.98,58.75 U4.10 64.53,59.85 64.52,59.87 ; 65,59.84 65.03,59.81 U4.9 ; R53.2 68,62.38 67.31,63.07 64.34,63.07 63.88,62.61
  TOP w1.016: 63.3,61.82 63.3,64.57 UNK5V_PDA.1
5V0_6201U: length 15
  TOP w0.305: 11.33,20.75 11.33,20.75 U5.10 10.23,21.3 10.21,21.29 ; R54.2 7.7,24.77 7.01,24.08 7.01,21.11 7.47,20.65 ; 10.24,21.77 10.27,21.8 U5.9
  TOP w1.016: UNK5V_DA.1 4.34,17.86 6.55,20.07 7.57,20.07
5V0_G140: length 32.3
  TOP w0.203: R102.1 v1(15.67,17.82)
  TOP w0.254: U23.15 8,11.19 7.67,11.52 R107.2 ; R103.1 19.51,11.52 19.18,11.19 U23.2
  TOP w0.305: U3.3 21.97,17.71 ; 20.37,18.64 20.39,18.67 U3.1 20.97,17.69 ; U3.2 21.47,17.71
  TOP w0.381: 18.87,17.53 TP8.1 18.19,16.84
  L3_SIG w1.27: v1(6.96,16.36) v1(7.67,16.36) v1(8.38,16.36) v1(18.8,16.36) v1(19.51,16.36) v1(20.22,16.36)
  vias: v1(6.96,15.65) v1(7.67,15.65) v1(8.38,15.65) v1(13.54,17.78) v1(14.25,17.79) v1(14.96,17.81) v1(18.8,15.65) v1(19.51,15.65) v1(20.22,15.65)
5V0_VDC1: length 12
  TOP w0.254: U23.1 15.8,10.74 15.88,10.67 19.2,10.67 19.51,10.36 R103.2
  TOP w1.016: R103.2 19.51,3 VDC1.1
5V0_VDP1: length 13.2
  TOP w0.254: U23.16 11.38,10.74 11.3,10.67 7.98,10.67 7.67,10.36 R107.1
  TOP w1.016: VDP1.1 7.67,5.79 R107.1
5V6: length 68.7
  TOP w0.254: U10.8 49.23,37.31
  TOP w0.305: 52.81,20.93 52.37,20.93 52.24,21.07 U7.5 ; 51.67,23.09 U7.8 52.69,22.57 52.76,22.5 52.32,22.07 U7.7 ; 15.54,20.73 U5.1 16.5,21.3 ; 42.5,23.09 U8.8 43.52,22.57 43.59,22.5 43.15,22.07 U8.7 ; 64.53,53.58 U4.1 63.96,54.54 ; U4.2 65.03,53.58 ; 20.45,21.57 U3.8 20.97,22.59 21.03,22.66 21.47,22.22 U3.7 ; U8.5 43.07,21.07 43.21,20.93 43.64,20.93 ; U5.2 16.5,21.8
  TOP w0.381: R43.2 v1(65.53,52.08)
  TOP w0.508: v1(53.21,24.31) 55.3,24.31 55.96,23.65 55.96,7.92 56.85,7.03 R61.2 ; R62.2 v1(44.88,44.15) v1(44.17,44.15) ; R44.2 v1(17.04,24.99) ; v1(54.28,44.15) v1(53.57,44.15) R63.2 ; R59.2 65.8,44.75 C38.1
  TOP w0.762: TP11.1 63.78,44.6
  BOTTOM w0.305: U9.7 59.44,50.4 59.23,50.19 58.56,50.19 C41.1 58.94,50.62 U9.8 58.42,51.53 58.42,51.54
  BOTTOM w0.381: v1(58.54,48.69) v1(58.54,49.4) C41.1
  BOTTOM w0.508: R57.1 64.52,43.94 v1(64.34,44.12)
  vias: v1(16.28,20.52) v1(16.28,19.81) v1(16.99,20.52) v1(16.99,19.81) v1(19.23,23.11) v1(19.23,22.4) v1(19.94,23.11) v1(19.94,22.4) v1(43.33,24.31) v1(43.33,23.6) v1(44.04,24.31) v1(44.04,23.6) v1(48.87,41.73) v1(48.87,41.02) v1(48.87,40.31) v1(49.58,41.73) v1(49.58,41.02) v1(49.58,40.31) v1(52.5,24.31) v1(52.5,23.6) v1(53.21,23.6) v1(63.04,53.8) v1(63.04,53.09) v1(63.58,44.88) v1(63.58,44.12) v1(63.58,43.36) v1(63.75,53.8) v1(63.75,53.09) v1(64.34,44.88) v1(64.34,43.36)
48V0_7000_2: length 2
  TOP w0.381: R39.1 v1(81.53,30.48)
  TOP w0.508: R47.1 77.67,51.49
  vias: v1(79.4,30.48) v1(80.04,50.62) v1(80.04,49.91) v1(80.04,49.2) v1(80.11,30.48) v1(80.75,50.62) v1(80.75,49.91) v1(80.75,49.2) v1(80.82,30.48) v1(82.25,30.48) v1(82.96,30.48) v1(83.67,30.48)
48V0_G140: length 67.6
  TOP w0.203: R106.1 v1(49.71,17.82)
  TOP w0.254: U30.2 53.21,11.19 53.54,11.52 R143.1 ; U30.15 42.04,11.19 41.71,11.52 R145.2
  TOP w0.381: R17.1 v1(81.53,8.89)
  L3_SIG w1.27: v1(41,16.36) v1(41.71,16.36) v1(42.42,16.36) v1(52.83,16.36) v1(53.54,16.36) v1(54.25,16.36) v1(54.25,15.65) 58.47,11.43 62.84,11.43 64.34,9.93 64.34,8.36 68.76,3.94 74.4,3.94 75.56,5.11 77.7,5.11 79.4,6.81 v1(79.4,8.89) v1(80.11,8.89) v1(80.82,8.89) v1(81.53,8.89) v1(82.25,8.89) v1(82.96,8.89) v1(83.67,8.89)
  vias: v1(41,15.65) v1(41.71,15.65) v1(42.42,15.65) v1(47.57,17.78) v1(48.29,17.79) v1(49,17.81) v1(52.83,15.65) v1(53.54,15.65)
48V0_GTRB: length 61.7
  TOP w0.203: R149.1 v1(32.69,17.82)
  TOP w0.254: U31.15 25.02,11.19 24.69,11.52 R152.2 ; U31.2 36.2,11.19 36.53,11.52 R150.1
  TOP w0.381: R128.1 v1(59.94,8.89)
  L3_SIG w1.27: v1(62.08,8.89) v1(61.37,8.89) v1(60.66,8.89) v1(59.94,8.89) v1(59.23,8.89) v1(58.52,8.89) v1(57.81,8.89) 54.05,8.89 51.36,6.2 42.04,6.2 37.24,11 v1(37.24,15.65) v1(37.24,16.36) v1(36.53,16.36) v1(35.81,16.36) v1(25.4,16.36) v1(24.69,16.36) v1(23.98,16.36)
  vias: v1(23.98,15.65) v1(24.69,15.65) v1(25.4,15.65) v1(30.56,17.78) v1(31.27,17.79) v1(31.98,17.81) v1(35.81,15.65) v1(36.53,15.65)
48V0_VDC2: length 12.6
  TOP w0.254: U30.1 49.84,10.74 49.91,10.67 53.24,10.67 53.54,10.36 R143.2
  TOP w1.016: VDC2.1 53.54,4.37 R143.2
48V0_VDP2: length 15.3
  TOP w0.254: U30.16 45.41,10.74 45.34,10.67 42.01,10.67 41.71,10.36 R145.1
  TOP w1.016: R145.1 41.71,4.83 43.61,2.92 VDP2.1
48V0_VIN: length 18.8
  TOP w0.508: v1(89.87,49.48) 89.87,46.93 R31.1 ; R9.1 89.87,25.34 v1(89.87,27.89) ; v1(68.28,27.89) 68.28,25.34 R120.1
  BOTTOM w0.305: R29.2 v1(89.87,49.48) ; R118.2 v1(68.28,27.89) ; R7.2 v1(89.87,27.89)
  BOTTOM w0.508: R114.1 v1(65.55,15.21) ; R3.1 v1(87.14,15.21) ; v1(95.02,48.31) 94.3,49.03 R22.2 ; R24.1 v1(87.14,36.8) ; R113.2 72.71,27.44 v1(73.43,26.72) ; R2.2 94.3,27.44 v1(95.02,26.72)
  vias: v1(75.44,26.16) v1(75.44,25.45) v1(75.44,24.74) v1(76.15,26.16) v1(76.15,25.45) v1(76.15,24.74) v1(76.86,26.16) v1(76.86,25.45) v1(76.86,24.74) v1(96.06,58.06) v1(96.06,57.35) v1(96.06,56.64) v1(96.06,55.93) v1(96.06,55.22) v1(96.77,58.06) v1(96.77,57.35) v1(96.77,56.64) v1(96.77,55.93) v1(96.77,55.22) v1(97.03,47.75) v1(97.03,47.04) v1(97.03,46.33) v1(97.03,26.16) v1(97.03,25.45) v1(97.03,24.74) v1(97.49,58.06) v1(97.49,57.35) v1(97.49,56.64) v1(97.49,55.93) v1(97.49,55.22) v1(97.74,47.75) v1(97.74,47.04) v1(97.74,46.33) v1(97.74,26.16) v1(97.74,25.45) v1(97.74,24.74) v1(98.45,47.75) v1(98.45,47.04) v1(98.45,46.33) v1(98.45,26.16) v1(98.45,25.45) v1(98.45,24.74)
+12V0: length 45.7
  TOP w0.381: C56.2 46.33,28 R66.2 v1(46.28,27.1)
  BOTTOM w0.305: U29.4 23.77,59.62 C196.1 ; U15.4 56.99,59.62 C90.1 ; U28.4 14.32,59.62 C195.1 ; U18.4 30.93,59.62 C119.1 ; U19.4 40.38,59.62 C120.1 ; C89.1 47.54,59.62 U14.4
  BOTTOM w0.381: v1(42.98,33.88) 43.76,33.88 46.28,31.37 v1(46.28,27.1)
  BOTTOM w0.508: A2.7 53.8,57.93 C79.1 C84.1 v1(53.81,59.74) ; v1(37.19,59.74) C114.1 C109.1 37.19,57.93 A4.7 ; C90.1 v1(56.99,58.83) ; A1.7 44.35,57.93 C77.1 C82.1 v1(44.36,59.74) ; C196.1 v1(23.77,58.83) ; C120.1 v1(40.38,58.83) ; v1(11.13,59.74) C188.1 C183.1 11.13,57.93 A5.7 ; A3.7 27.74,57.93 C107.1 C112.1 v1(27.74,59.74) ; A6.7 20.57,57.93 C185.1 C190.1 v1(20.58,59.74) ; v1(30.93,58.83) C119.1 ; v1(47.54,58.83) C89.1 ; v1(14.32,58.83) C195.1
  vias: v1(42.34,34.95) v1(42.34,34.24) v1(42.98,34.59)
-12V0: length 69.5
  TOP w0.381: C57.1 52.4,28 R65.1 v1(52.45,27.1)
  BOTTOM w0.305: U18.PAD 29.14,61.77 U18.7 26.17,61.77 C117.1 ; U19.PAD 38.59,61.77 U19.7 35.69,61.77 C118.1 ; U15.PAD 55.2,61.77 U15.7 52.28,61.77 C88.1 ; U28.PAD 12.53,61.77 U28.7 9.55,61.77 C193.1 ; C194.1 19,61.77 U29.7 21.98,61.77 U29.PAD ; U14.PAD 45.75,61.77 U14.7 42.8,61.77 C87.1
  BOTTOM w0.381: v1(59.79,41.91) 57,41.91 55.91,40.82 55.91,30.56 v1(52.45,27.1)
  BOTTOM w0.508: A3.4 25.2,48.85 C106.1 C111.1 v1(25.2,47.04) ; C88.1 51.49,61.71 v1(51.44,61.76) ; C194.1 v1(18.21,61.76) ; v1(8.59,47.04) C187.1 C182.1 8.59,48.85 A5.4 ; C118.1 34.9,61.69 v1(34.82,61.76) ; v1(25.37,61.82) 25.43,61.76 C117.1 ; v1(18.03,47.04) C189.1 C184.1 18.03,48.85 A6.4 ; A4.4 34.65,48.85 C108.1 C113.1 v1(34.64,47.04) ; v1(51.25,47.04) C83.1 C78.1 51.26,48.85 A2.4 ; A1.4 41.81,48.85 C76.1 C81.1 v1(41.82,47.04) ; C87.1 42.07,61.74 v1(41.99,61.82) ; C193.1 v1(8.76,61.76)
  vias: v1(59.79,42.62) v1(60.5,42.62) v1(60.5,41.91)
GND: length 597.5
  TOP w0.102: U20.E2 35.01,29.22 35.89,29.22 36.3,28.8 36.42,28.8
  TOP w0.203: U20.F7 v2(31.11,29.22) ; U20.C1 v2(35.01,27.27) U20.C2 ; 67.32,55.52 R45.1 68,56.14 ; U20.B7 U20.A7 v2(31.43,25.76) ; U20.H11 v2(28.51,30.52) ; U20.E10 v2(29.16,29.22) ; v2(29.16,29.22) U20.E11 ; v2(29.16,29.22) U20.F10 ; U20.L5 v2(32.73,33.25) ; 36.47,30.45 36.4,30.38 35.52,30.38 U20.G1 v2(35.01,30.52) U20.G2 ; U20.B10 v2(29.16,26.62) U20.A11 ; U20.E2 v2(35.01,28.57) ; U20.B1 v2(35.01,26.62) ; 67.32,57.74 R55.1 68,57.12 ; U20.B3 U20.C4 v2(33.71,27.92) ; U20.F8 v2(30.46,29.22) ; U20.D4 v2(33.71,28.57) U20.E4 ; U20.G3 v2(34.36,30.52) ; U20.A1 v2(35.01,25.97) ; U20.F9 v2(29.81,29.22) ; U20.E3 v2(34.36,28.57)
  TOP w0.254: U23.12 11.32,12.54 v1(11.05,12.27) ; v1(28.07,12.27) 28.34,12.54 U31.12 ; v1(51,32.18) 50.47,32.18 50.23,32.43 U10.5 ; U30.12 45.36,12.54 v1(45.09,12.27)
  TOP w0.279: C28.2 72.47,50.28 v1(72.69,50.06) ; U6.PAD 72.81,46.47 U6.8 72.81,45.1 v1(72.59,44.88)
  TOP w0.305: R50.1 64.94,61.45 65.51,60.88 C32.2 v1(65.64,60.1) 65.53,59.99 U4.8 ; 11.46,51.61 11.72,51.88 U26.30 ; C24.2 v1(63.91,55.54) ; v1(13.77,56.87) 13.77,56.57 14.46,55.87 U26.22 ; v1(21.97,22.63) U3.6 21.97,20.37 U3.PAD ; C98.2 v1(29.44,47.84) ; v1(63.12,56.64) v1(65.53,56.64) v1(68,56.64) ; U16.22 31.08,55.87 30.38,56.57 v1(30.38,56.87) ; C35.2 v1(63.91,57.74) ; R51.1 8.62,21.71 9.19,22.28 C33.2 v1(9.98,22.41) 10.09,22.3 U5.8 ; C25.2 v1(14.54,20.68) ; U16.30 28.33,51.88 28.07,51.61 ; C67.2 v1(44.48,47.84) ; v1(52.73,21.57) U7.6 50.47,21.57 U7.PAD ; C174.2 v1(12.83,47.84) ; 44.68,51.61 44.94,51.88 U12.30 ; U8.PAD 41.3,21.57 U8.6 v1(43.56,21.57) ; C68.2 v1(46.05,47.84) ; U12.22 47.69,55.87 46.99,56.57 v1(46.99,56.87) ; C97.2 v1(27.86,47.84) ; C173.2 v1(11.25,47.84) ; v1(13.44,24.77) v1(13.44,22.3) v1(13.44,19.89) ; C36.2 v1(12.34,20.68)
  TOP w0.381: 32.23,57.83 C96.2 ; C96.2 32.87,58.43 ; C96.2 33.05,58.01 v1(33.66,58.01) ; C66.2 49.48,58.43 ; C66.2 49.66,58.01 v1(50.27,58.01) ; C66.2 48.84,57.83 ; 7.81,63.71 R130.2 ; R130.2 8.48,63.09 ; R130.2 9.16,63.71 ; 80.32,1.99 R93.2 ; R93.2 80.32,3.34 ; R93.2 79.7,2.67 ; 99.03,50.85 GND3.1 ; GND3.1 100.1,51.92 ; GND3.1 99.03,52.98 ; GND3.1 97.97,51.92 ; v1(50.44,19.38) C46.2 49.67,20.13 49.68,20.14 ; R68.2 26.03,64.28 ; R68.2 26.03,62.93 ; R68.2 26.65,63.6 ; 10.15,41.09 R173.2 10.77,40.41 ; 15.62,57.83 C172.2 ; C172.2 16.26,58.43 ; C172.2 16.44,58.01 v1(17.04,58.01) ; 81.47,55.35 C1.1 ; C1.1 82.58,54.04 ; C1.1 82.58,56.66 ; v1(24.16,20.35) C30.2 23.4,19.58 23.39,19.58 ; R56.1 12.96,24.77 ; R56.1 12.34,24.09 ; R56.1 12.34,25.44 ; 44.68,51.61 43.38,50.32 41.5,50.32 41.33,50.15 R70.1 ; 28.6,22.04 C210.1 27.96,22.64 ; R166.2 21.61,61.79 ; R166.2 22.23,61.11 ; R166.2 21.61,60.44 ; R46.1 14.56,25.44 ; R46.1 13.94,24.77 ; R46.1 14.56,24.09 ; R69.2 34.49,64.38 ; R69.2 35.11,63.7 ; R69.2 34.49,63.03 ; 56.08,66.04 GND1.1 ; GND1.1 57.15,67.11 ; GND1.1 57.15,64.97 ; GND1.1 58.22,66.04 ; R81.1 24.72,50.15 24.89,50.32 26.77,50.32 28.07,51.61 ; R161.2 46,61.11 ; R161.2 45.38,60.44 ; R161.2 45.38,61.79 ; C171.1 v1(15.47,57.83) ; 11.46,51.61 10.16,50.32 8.28,50.32 8.11,50.15 R132.1 ; R45.1 68.67,55.52 ; 97.97,11.02 GND4.1 ; GND4.1 100.1,11.02 ; GND4.1 99.03,9.96 ; GND4.1 99.03,12.09 ; 39.83,61.97 R41.2 ; R41.2 39.15,62.59 ; R41.2 40.5,62.59 ; 29.39,61.11 R163.2 28.77,60.44 ; 76.53,2.53 DS1.C ; DS1.C 77.22,1.74 ; DS1.C v1(79.04,2.53) ; 4.08,59.43 R167.2 ; R167.2 4.75,60.05 ; R167.2 5.42,59.43 ; R165.2 12.78,61.11 ; R165.2 12.16,61.79 ; R165.2 12.16,60.44 ; R42.2 51.8,63.73 ; R42.2 51.17,63.05 ; R42.2 51.17,64.4 ; R164.2 38.22,61.79 ; R164.2 38.84,61.11 ; R164.2 38.22,60.44 ; C65.1 v1(48.69,57.83) ; 17.49,62.72 R131.2 16.81,62.1 ; 29.69,22.04 C211.1 30.33,22.64 ; 45.9,47.84 C67.2 45.26,47.24 ; C123.2 v1(41.62,29.08) ; C123.2 42.22,29.87 ; C123.2 41.62,30.51 ; C122.2 v1(41.62,28.17) ; C122.2 41.62,26.75 ; C122.2 42.22,27.38 ; R162.2 55.45,61.11 ; R162.2 54.83,60.44 ; R162.2 54.83,61.79 ; v1(41.27,19.38) C47.2 40.51,20.13 40.51,20.14 ; 69.4,2.54 DS3.C ; DS3.C 70.1,1.84 ; DS3.C 71.12,2.54 ; 28.65,47.24 C97.2 29.29,47.84 ; C95.1 v1(32.08,57.83) ; 12.68,47.84 C173.2 12.04,47.24 ; R55.1 68.67,57.74
  TOP w0.457: P5.5 v1(7.24,27.53)
  TOP w0.508: C145.2 v1(11.48,31.39) ; v1(20.62,42.89) 20.34,43.18 R110.2 20.44,43.84 U24.2 25.61,43.84 C155.2 26.43,43.88 v1(26.47,43.92) ; v1(24.16,20.35) 24.19,20.38 R159.2 ; C93.1 C102.1 v1(23.95,53.09) ; C152.2 v1(17.17,14.57) ; v1(35.05,21.06) 35.05,21.18 34.28,21.96 Y1.2 ; v1(38.48,53.09) C104.1 C94.1 ; C55.2 v1(49.2,28.09) ; v1(6.5,33.93) 6.96,33.48 C143.2 ; P6.9 v1(4.42,37.13) ; R132.1 v1(7.32,49.53) ; R81.1 v1(23.93,49.53) ; C63.1 C72.1 v1(40.56,53.09) ; P6.3 v1(4.42,40.94) ; C144.2 v1(11.48,26.92) ; P6.5 v1(4.42,39.67) ; R67.1 v1(45.19,31.14) ; C170.1 C180.1 v1(21.87,53.09) ; C200.2 v1(51.21,14.57) ; C64.1 C74.1 v1(55.09,53.09) ; E1.2 v1(2.29,20.62) ; 69.42,50.72 69.51,50.81 C29.2 v1(68.53,51.99) ; C121.2 v1(34.37,20.55) ; U21.2 v1(9.04,26.62) ; C48.1 v1(50.77,46.02) ; v1(17.53,40.16) 17.38,40.3 R146.1 ; R157.2 v1(18.11,25.02) ; 62.05,2.92 GND2.1 ; GND2.1 63.88,4.75 ; GND2.1 65.71,2.92 ; C43.1 v1(47.68,46.02) ; v1(31.47,23.24) 31.5,23.24 31.51,23.26 Y1.4 ; C124.2 v1(35.74,21.49) ; R94.2 v1(4.06,20.75) ; C169.1 C178.1 v1(7.34,53.09) ; R70.1 v1(40.54,49.53) ; C204.2 v1(34.19,14.57)
  TOP w0.762: 84.71,64.85 P2.2 ; P2.2 85.91,66.04 ; P2.2 87.1,64.85 ; P1.3 71.73,59.58 ; P1.3 70.78,57.78 ; P1.3 72.68,57.78 ; P1.3 71.73,55.98 ; P1.2 76.43,61.83 ; P1.2 76.43,59.93 ; P1.2 74.62,60.88
  L2_GND w0.381: 57.15,64.97 GND1.1 ; GND1.1 57.15,67.11 ; GND1.1 58.22,66.04 ; GND1.1 56.08,66.04 ; 97.97,51.92 GND3.1 ; GND3.1 99.03,50.85 ; GND3.1 99.03,52.98 ; GND3.1 100.1,51.92 ; GND4.1 99.03,12.09 ; GND4.1 99.03,9.96 ; GND4.1 100.1,11.02 ; GND4.1 97.97,11.02
  L2_GND w0.508: GND2.1 65.71,2.92 ; GND2.1 63.88,4.75 ; GND2.1 62.05,2.92
  L2_GND w0.762: P2.2 85.91,66.04 ; P2.2 84.71,64.85 ; P2.2 85.91,63.65 ; P2.2 87.1,64.85 ; P1.2 76.43,61.83 ; P1.2 76.43,59.93 ; P1.2 78.23,60.88 ; P1.2 74.62,60.88 ; 71.73,55.98 P1.3 ; P1.3 71.73,59.58 ; P1.3 72.68,57.78 ; P1.3 70.78,57.78
  L3_SIG w0.381: 56.08,66.04 GND1.1 ; GND1.1 58.22,66.04 ; GND1.1 57.15,67.11 ; GND1.1 57.15,64.97 ; GND4.1 100.1,11.02 ; GND4.1 97.97,11.02 ; GND4.1 99.03,12.09 ; GND4.1 99.03,9.96 ; GND3.1 100.1,51.92 ; GND3.1 99.03,52.98 ; GND3.1 99.03,50.85 ; GND3.1 97.97,51.92
  L3_SIG w0.508: GND2.1 63.88,4.75 ; GND2.1 65.71,2.92 ; GND2.1 62.05,2.92
  L3_SIG w0.762: 74.62,60.88 P1.2 ; P1.2 76.43,59.93 ; P1.2 76.43,61.83 ; P1.2 78.23,60.88 ; P2.2 87.1,64.85 ; P2.2 85.91,66.04 ; P2.2 84.71,64.85 ; P2.2 85.91,63.65 ; 70.78,57.78 P1.3 ; P1.3 71.73,55.98 ; P1.3 72.68,57.78 ; P1.3 71.73,59.58
  L4_PWR w0.381: 56.08,66.04 GND1.1 ; GND1.1 58.22,66.04 ; GND1.1 57.15,67.11 ; GND1.1 57.15,64.97 ; GND4.1 99.03,12.09 ; GND4.1 100.1,11.02 ; GND4.1 97.97,11.02 ; GND4.1 99.03,9.96
  L4_PWR w0.508: 62.05,2.92 GND2.1 ; GND2.1 65.71,2.92 ; GND2.1 63.88,4.75
  L4_PWR w0.762: P2.2 85.91,66.04 ; P2.2 85.91,63.65 ; P2.2 87.1,64.85 ; P2.2 84.71,64.85 ; 70.78,57.78 P1.3 ; P1.3 72.68,57.78 ; P1.3 71.73,55.98 ; P1.3 71.73,59.58 ; P1.2 78.23,60.88 ; P1.2 76.43,59.93 ; P1.2 76.43,61.83 ; P1.2 74.62,60.88
  L5_GND w0.381: GND3.1 99.03,52.98 ; GND3.1 97.97,51.92 ; GND3.1 99.03,50.85 ; GND3.1 100.1,51.92 ; 97.97,11.02 GND4.1 ; GND4.1 100.1,11.02 ; GND4.1 99.03,12.09 ; GND4.1 99.03,9.96 ; 57.15,64.97 GND1.1 ; GND1.1 57.15,67.11 ; GND1.1 56.08,66.04 ; GND1.1 58.22,66.04
  L5_GND w0.508: GND2.1 65.71,2.92 ; GND2.1 62.05,2.92 ; GND2.1 63.88,4.75
  L5_GND w0.762: P2.2 87.1,64.85 ; P2.2 84.71,64.85 ; P2.2 85.91,66.04 ; P2.2 85.91,63.65 ; 70.78,57.78 P1.3 ; P1.3 71.73,59.58 ; P1.3 71.73,55.98 ; P1.3 72.68,57.78 ; P1.2 76.43,61.83 ; P1.2 78.23,60.88 ; P1.2 74.62,60.88 ; P1.2 76.43,59.93
  BOTTOM w0.305: v2(31.43,25.76) 31.68,25.5 C134.1 C131.1 31.68,23.45 v1(31.47,23.24) ; v1(33.55,24.46) 33.71,24.61 C142.1 ; v2(35.01,25.97) 35.33,25.97 C138.2 ; C212.1 31.75,28.96 31.49,29.22 v2(31.11,29.22) ; C126.2 32.66,35.31 v1(32.31,35.66) 31.9,35.66 31.65,35.41 C132.2 ; U19.3 40.89,61.27 41.3,60.86 v1(41.3,60.4) ; U9.4 60.44,54.7 60.63,54.89 60.96,54.89 61.16,55.08 C42.2 ; U29.3 24.28,61.27 24.69,60.86 v1(24.69,60.4) ; v2(33.71,27.92) 33.72,27.9 C141.1 ; v2(29.16,26.62) 29.2,26.57 C209.1 C137.2 ; U28.3 v1(15.39,61.27) ; U14.3 v1(48.61,61.27) ; U15.3 v1(58.06,61.27) ; U18.3 v1(32,61.27)
  BOTTOM w0.33: C150.2 v1(24.71,32.49) ; C147.2 14.66,33.55 14.88,33.32 v1(14.88,32.69) 14.88,32.18 15.05,32.02 U22.16 v1(18.26,32.02) ; U22.6 v1(20.14,31.38)
  BOTTOM w0.381: v1(43.59,60.35) 43.16,60.35 C87.2 ; 12.57,44.6 C186.2 11.94,45.19 ; v1(71.09,18.03) 70.4,18.73 R117.2 70.98,19.38 C161.2 ; R52.1 70.48,46.38 ; R52.1 71.54,45.68 71.75,45.47 C37.1 72.52,44.95 v1(72.59,44.88) ; R52.1 69.68,45.68 ; GND4.1 100.1,11.02 ; GND4.1 99.03,9.96 ; GND4.1 97.97,11.02 ; 35.41,64.59 35.41,63.85 C116.1 ; v1(74.5,7.44) 74.52,7.46 Q4.2 ; v1(57.95,57.3) v1(57.95,56.59) C52.2 ; C127.2 26.01,29.01 ; C127.2 C136.2 26.03,30.02 ; C127.2 C133.2 25.98,27.99 v1(25.96,27.97) ; C12.2 93.12,21.87 92.84,21.6 R5.2 91.32,21.6 v1(91.24,21.51) ; C7.2 92.57,19.38 R6.2 91.99,18.73 v1(92.68,18.03) ; C41.2 v1(57.54,49.4) v1(57.54,48.69) ; Q4.2 73.91,8.69 ; Q4.2 74.52,9.52 ; Q4.2 75.13,8.69 ; 49.96,9.58 JP10.3 49.96,11.71 ; 33.68,45.36 U13.4 32.28,45.97 ; C23.2 93.12,43.46 92.84,43.19 R27.2 91.32,43.19 v1(91.24,43.1) ; C51.2 v1(62.23,50.22) ; 97.97,51.92 GND3.1 ; GND3.1 99.03,52.98 ; GND3.1 99.03,50.85 ; GND3.1 100.1,51.92 ; v1(69.65,21.51) 69.73,21.6 R116.2 71.25,21.6 71.53,21.87 C166.2 ; 57.15,64.97 GND1.1 ; GND1.1 56.08,66.04 ; GND1.1 57.15,67.11 ; GND1.1 58.22,66.04 ; 56.59,53.42 C45.2 ; C45.2 57.86,53.42 ; C45.2 v1(57.23,52.65) ; 88.53,50.46 R23.2 88.53,52.46 ; 6.32,40.26 U27.4 5.71,38.86 ; 32.94,11.71 JP12.3 32.94,9.58 ; 12.16,30.89 C149.2 12.76,30.25 ; 64.61,50.08 R155.2 ; R155.2 64.61,51.42 ; R155.2 65.23,50.75 ; C18.2 92.57,40.97 R28.2 91.99,40.32 v1(92.68,39.62) ; v1(26.97,60.35) 26.58,60.35 C117.2 ; C42.2 v1(61.95,55.78) ; 15.93,11.71 JP6.3 15.93,9.58 ; 2.95,45.14 v1(2.95,44.35)
  BOTTOM w0.508: v1(12.13,59.74) C188.2 C183.2 13.11,57.94 ; C149.2 12.76,31.5 v1(12.93,31.67) ; v1(31.19,12.32) 31.27,12.4 JP11.3 ; C105.2 v1(26.47,43.92) ; R160.2 v1(65.79,29.87) ; v1(36.4,63.72) 36.32,63.64 C116.1 ; C181.2 v1(7.59,47.98) ; C125.2 37.87,32.94 38.1,32.72 v1(38.1,32.21) 37.82,31.93 C130.2 ; C76.2 C81.2 v1(42.82,47.04) ; v1(38.19,59.74) C114.2 C109.2 39.12,57.94 ; C115.1 v1(26.95,63.72) ; v1(53.01,63.72) 52.91,63.62 C86.1 ; v1(7.86,35.05) C175.2 C176.2 ; C22.2 C21.2 84.91,38.52 R34.2 v1(85.95,38.52) ; 46.25,57.94 C77.2 C82.2 v1(45.36,59.74) ; C128.2 26.9,19.79 ; C128.2 24.59,20.78 v1(24.16,20.35) ; C128.2 C129.2 ; v1(12.01,34.32) C146.2 C148.2 C147.2 ; v1(16.51,45.47) 16.51,45.9 16.79,46.18 U17.4 ; C195.2 v1(13.32,58.83) ; 22.5,57.94 C185.2 C190.2 v1(21.58,59.74) ; C120.2 v1(39.38,58.83) ; C160.2 70.33,27.74 71.02,28.42 v1(71.45,28.42) ; v1(33.64,47.04) C113.2 C108.2 ; C208.2 40.69,65.84 ; 42.77,64.49 C85.1 43.48,63.64 v1(43.56,63.72) ; C11.2 C10.2 84.91,16.93 R12.2 v1(85.95,16.93) ; R172.2 v1(87.48,29.87) ; C193.2 v1(8.76,60.76) ; C191.1 v1(10.34,63.72) ; v1(28.45,43.79) 28.49,43.83 C69.2 C70.2 ; JP6.3 14.48,10.64 v1(14.17,10.95) ; C194.2 v1(18.21,60.76) ; U13.4 v1(30.56,45.36) ; U27.4 6.32,36.5 v1(6.05,36.22) ; C192.1 v1(19.79,63.72) ; C129.2 29.24,19.9 ; C129.2 30.66,20.78 v1(30.68,20.75) ; 62.05,2.92 GND2.1 ; GND2.1 65.71,2.92 ; GND2.1 63.88,4.75 ; v1(9.59,47.04) C187.2 C182.2 ; C80.2 v1(45.11,45.14) ; C184.2 C189.2 v1(17.03,47.04) ; JP10.3 48.51,10.64 v1(48.21,10.95) ; v1(28.74,59.74) C112.2 C107.2 29.69,57.94 ; C165.2 C164.2 63.32,16.93 R123.2 v1(64.36,16.93) ; v1(54.81,59.74) C84.2 C79.2 55.63,57.94 ; v1(51.44,60.76) 51.49,60.71 C88.2 ; JP9.3 48.29,12.4 v1(48.21,12.32) ; C99.2 C100.2 v1(15.47,45.47) ; C206.2 v1(28.57,8.23) ; C3.2 91.92,27.74 92.61,28.42 v1(93.04,28.42) ; v1(34.82,60.76) 34.9,60.69 C118.2 ; C119.2 v1(29.93,58.83) ; C110.2 27.95,44.92 ; v1(31.19,10.95) 31.5,10.64 JP12.3 ; C90.2 v1(55.99,58.83) ; v1(29.08,35.69) 29.16,35.61 C139.2 C140.2 ; C89.2 v1(46.54,58.83) ; C207.2 33.07,65.84 ; R179.1 v1(66.67,14.2) ; C17.2 91.92,49.33 92.61,50.01 v1(93.04,50.01) ; C75.2 v1(39.37,42.32) ; v1(13.44,45.52) 13.11,45.19 C186.2 ; C197.2 17.83,65.84 ; C60.2 55.93,65.84 ; C202.2 v1(45.59,8.23) ; C198.2 25.45,65.84 ; C106.2 C111.2 v1(26.2,47.04) ; C54.2 48.31,65.84 ; v1(50.25,47.04) C83.2 C78.2 ; R176.1 v1(88.27,35.79) ; JP5.3 14.25,12.4 v1(14.17,12.32) ; C154.2 v1(11.56,8.23) ; 16.89,8.23 v1(15.62,8.23) ; R23.2 v1(87.48,51.46) ; R175.1 v1(88.27,14.2) ; C196.2 v1(22.77,58.83) ; C203.2 v1(32.64,8.23) ; C199.2 v1(49.66,8.23)
  BOTTOM w0.762: P1.3 71.73,59.58 ; P1.3 70.78,57.78 ; P1.3 72.68,57.78 ; P1.3 71.73,55.98 ; P2.2 85.91,66.04 ; P2.2 85.91,63.65 ; P2.2 84.71,64.85 ; P2.2 87.1,64.85 ; 74.62,60.88 P1.2 ; P1.2 76.43,61.83 ; P1.2 78.23,60.88 ; P1.2 76.43,59.93
  vias: v1(1.52,59.64) v1(1.52,54.56) v1(1.52,49.48) v1(1.52,44.4) v1(1.52,34.24) v1(1.52,19) v1(1.52,13.92) v1(1.52,8.84) v1(6.25,17.78) v1(7.39,67.06) v1(8.03,1.52) v1(9.07,6.1) v1(9.32,41.58) v1(10.57,17.78) v1(11.3,17.78) v1(11.56,8.97) v1(11.56,7.49) v1(12.04,17.78) v1(12.29,8.97) v1(12.29,8.23) v1(12.29,7.49) v1(12.42,67.06) v1(12.8,40.34) v1(12.78,17.78) v1(12.88,22.96) v1(12.88,21.64) v1(13,13.69) v1(13,12.32) v1(13,10.95) v1(13.13,5.28) v1(13.11,1.52) v1(13.26,36.78) v1(13.59,13) v1(13.59,11.63) v1(13.79,54.05) v1(13.79,53.34) v1(13.79,52.63) v1(13.79,51.92) v1(13.79,51.21) v1(14,22.96) v1(14,21.64) v1(14.17,13.69) v1(14.38,30.23) v1(14.38,28.09) v1(14.5,54.05) v1(14.5,53.34) v1(14.5,52.63) v1(14.5,51.92) v1(14.5,51.21) v1(14.88,8.97) v1(14.88,8.23) v1(14.88,7.49) v1(15.21,54.05) v1(15.21,53.34) v1(15.21,52.63) v1(15.21,51.92) v1(15.21,51.21) v1(15.62,8.97) v1(15.62,7.49) v1(15.93,54.05) v1(15.93,53.34) v1(15.93,52.63) v1(15.93,51.92) v1(15.93,51.21) v1(16.64,54.05) v1(16.64,53.34) v1(16.64,52.63) v1(16.64,51.92) v1(16.64,51.21) v1(18.03,67.06) v1(18.19,1.52) v1(18.39,5.31) v1(18.49,20.65) v1(18.49,19.58) v1(18.59,27.71) v1(19.3,27.71) v1(20.02,67.06) v1(20.07,20.65) v1(20.07,19.58) v1(20.65,5.28) v1(20.83,20.65) v1(20.83,19.58) v1(21.72,20.65) v1(21.72,19.58) v1(22.05,5.33) v1(22.2,35.94) v1(22.33,37.97) v1(22.61,20.65) v1(22.61,19.58) v1(23.27,1.52) v1(25.68,67.06) v1(27.58,17.78) v1(27.66,67.06) v1(28.32,17.78) v1(28.57,8.97) v1(28.57,7.49) v1(29.06,17.78) v1(29.31,8.97) v1(29.31,8.23) v1(29.31,7.49) v1(29.79,17.78) v1(30.02,13.69) v1(30.02,12.32) v1(30.02,10.95) v1(30.4,54.05) v1(30.4,53.34) v1(30.4,52.63) v1(30.4,51.92) v1(30.4,51.21) v1(30.38,41.99) v1(30.61,22.15) v1(30.61,13) v1(30.61,11.63) v1(30.78,5.38) v1(31.11,54.05) v1(31.11,53.34) v1(31.11,52.63) v1(31.11,51.92) v1(31.11,51.21) v1(31.19,13.69) v1(31.34,1.52) v1(31.83,54.05) v1(31.83,53.34) v1(31.83,52.63) v1(31.83,51.92) v1(31.83,51.21) v1(31.9,8.97) v1(31.9,8.23) v1(31.9,7.49) v1(32.54,54.05) v1(32.54,53.34) v1(32.54,52.63) v1(32.54,51.92) v1(32.54,51.21) v1(32.64,8.97) v1(32.64,7.49) v1(33.27,67.06) v1(33.25,54.05) v1(33.25,53.34) v1(33.25,52.63) v1(33.25,51.92) v1(33.25,51.21) v1(33.4,4.09) v1(33.43,1.52) v1(34.47,43.36) v1(34.75,17.98) v1(35.28,67.06) v1(39.24,5.28) v1(39.78,1.52) v1(40.51,25.04) v1(40.51,23.47) v1(40.51,22.71) v1(40.51,21.82) v1(40.51,20.93) v1(40.61,2.95) v1(40.94,67.06) v1(41.58,25.04) v1(41.58,23.47) v1(41.58,22.71) v1(41.58,21.82) v1(41.58,20.93) v1(41.94,1.52) v1(42.85,67.06) v1(43.41,32.22) v1(43.41,31.51) v1(44.12,32.22) v1(44.12,31.51) v1(44.6,17.78) v1(45.34,17.78) v1(45.59,8.97) v1(45.59,7.49) v1(46.08,17.78) v1(46.33,8.97) v1(46.33,8.23) v1(46.33,7.49) v1(46.81,17.78) v1(47.02,54.05) v1(47.02,53.34) v1(47.02,52.63) v1(47.02,51.92) v1(47.02,51.21) v1(47.04,13.69) v1(47.04,12.32) v1(47.04,10.95) v1(47.62,13) v1(47.62,11.63) v1(47.73,54.05) v1(47.73,53.34) v1(47.73,52.63) v1(47.73,51.92) v1(47.73,51.21) v1(48.21,13.69) v1(48.34,34.75) v1(48.34,33.68) v1(48.29,4.85) v1(48.44,54.05) v1(48.44,53.34) v1(48.44,52.63) v1(48.44,51.92) v1(48.44,51.21) v1(48.54,67.06) v1(48.51,44.98) v1(48.51,44.27) v1(48.67,1.52) v1(48.92,8.97) v1(48.92,8.23) v1(48.92,7.49) v1(49.15,54.05) v1(49.15,53.34) v1(49.15,52.63) v1(49.15,51.92) v1(49.15,51.21) v1(49.23,44.98) v1(49.23,44.27) v1(49.23,34.75) v1(49.23,33.68) v1(49.68,25.04) v1(49.68,23.47) v1(49.68,22.71) v1(49.68,21.82) v1(49.68,20.93) v1(49.66,8.97) v1(49.66,7.49) v1(49.86,54.05) v1(49.86,53.34) v1(49.86,52.63) v1(49.86,51.92) v1(49.86,51.21) v1(49.94,44.98) v1(49.94,44.27) v1(50.11,34.75) v1(50.11,33.68) v1(50.52,67.06) v1(50.47,64.85) v1(50.75,25.04) v1(50.75,23.47) v1(50.75,22.71) v1(50.75,21.82) v1(50.75,20.93) v1(51.05,4.88) v1(53.16,17.81) v1(54.2,22.1) v1(55.09,19.79) v1(56.13,25.15) v1(56.21,5.49) v1(56.69,17.14) v1(57,30.28) v1(57,29.57) v1(57.63,25.58) v1(57.71,30.28) v1(57.71,29.57) v1(58.19,67.06) v1(58.57,45.12) v1(58.57,44.41) v1(58.8,53.52) v1(58.8,52.45) v1(58.83,1.52) v1(59.28,45.12) v1(59.28,44.41) v1(59.69,53.52) v1(59.69,52.45) v1(60.12,5.23) v1(60.58,53.52) v1(60.58,52.45) v1(62.69,31.14) v1(63.27,67.06) v1(64.08,32.49) v1(64.74,22.83) v1(64.74,21.72) v1(64.74,20.6) v1(64.77,19.58) v1(64.87,57.2) v1(64.87,56.08) v1(65.28,47.8) v1(65.3,5.26) v1(65.35,10.52) v1(65.51,50.75) v1(65.81,22.83) v1(65.81,21.72) v1(65.81,20.6) v1(65.84,19.58) v1(66.19,57.2) v1(66.19,56.08) v1(66.29,47.8) v1(66.7,48.74) v1(67.31,47.8) v1(67.31,46.79) v1(67.46,49.76) v1(67.46,48.74) v1(68.22,50.77) v1(68.22,49.76) v1(68.22,48.74) v1(68.22,47.73) v1(68.22,46.71) v1(68.35,67.06) v1(68.99,50.77) v1(68.99,49.76) v1(68.99,48.74) v1(68.99,47.73) v1(68.99,46.71) v1(68.99,1.52) v1(69.75,47.73) v1(69.75,46.71) v1(69.85,9.27) v1(70.61,12.65) v1(71.73,13.72) v1(71.73,12.65) v1(71.78,47.73) v1(71.78,46.71) v1(71.75,9.78) v1(72.67,47.73) v1(72.67,46.71) v1(72.85,15.85) v1(72.85,14.78) v1(72.85,13.72) v1(72.85,12.65) v1(73.43,67.06) v1(73.56,47.73) v1(73.56,46.71) v1(73.96,15.85) v1(73.96,14.78) v1(73.96,13.72) v1(73.96,12.65) v1(74.07,1.52) v1(74.3,10.95) v1(74.45,47.73) v1(74.45,46.71) v1(75.01,29.16) v1(75.08,15.85) v1(75.08,14.78) v1(75.34,47.73) v1(75.34,46.71) v1(75.39,45.14) v1(75.49,45.92) v1(75.87,47.22) v1(76.2,15.85) v1(76.2,14.78) v1(76.35,44.2) v1(76.94,30.56) v1(77.11,44.2) v1(77.11,43.43) v1(77.32,15.85) v1(77.32,14.78) v1(78.13,44.2) v1(78.13,43.43) v1(78.51,67.06) v1(79.15,44.2) v1(79.15,43.43) v1(79.15,1.52) v1(80.67,28.93) v1(80.85,53.75) v1(80.85,53.01) v1(80.85,52.27) v1(81.58,53.75) v1(81.58,53.01) v1(81.58,52.27) v1(82.32,53.75) v1(82.32,53.01) v1(82.32,52.27) v1(83.06,53.75) v1(83.06,53.01) v1(83.06,52.27) v1(83.59,67.06) v1(83.77,1.68) v1(86.33,44.42) v1(86.33,43.31) v1(86.33,42.19) v1(86.33,22.83) v1(86.33,21.72) v1(86.33,20.6) v1(86.36,41.17) v1(86.36,19.58) v1(87.06,1.68) v1(87.4,44.42) v1(87.4,43.31) v1(87.4,42.19) v1(87.43,41.17) v1(87.4,22.83) v1(87.4,21.72) v1(87.4,20.6) v1(87.43,19.58) v1(87.53,9.63) v1(87.78,31.55) v1(88.67,67.06) v1(89.33,10.52) v1(90.07,31.55) v1(90.34,1.68) v1(91.97,8.53) v1(92.2,34.24) v1(92.2,12.65) v1(93.32,35.31) v1(93.32,34.24) v1(93.32,13.72) v1(93.32,12.65) v1(93.6,1.68) v1(93.75,67.06) v1(94.44,37.44) v1(94.44,36.37) v1(94.44,35.31) v1(94.44,34.24) v1(94.44,15.85) v1(94.44,14.78) v1(94.44,13.72) v1(94.44,12.65) v1(94.39,1.52) v1(95.55,15.85) v1(95.55,14.78) v1(95.55,13.72) v1(95.55,12.65) v1(95.68,31.52) v1(96.67,37.44) v1(96.67,36.37) v1(96.67,15.85) v1(96.67,14.78) v1(97.79,37.44) v1(97.79,36.37) v1(97.79,15.85) v1(97.79,14.78) v1(98.91,37.44) v1(98.91,36.37) v1(98.91,15.85) v1(98.91,14.78) v1(100.08,59.56) v1(100.08,54.48) v1(100.08,49.4) v1(100.08,44.32) v1(100.08,39.24) v1(100.08,34.16) v1(100.08,29.08) v1(100.08,24) v1(100.08,18.92) v1(100.08,13.84) v1(100.08,8.76)

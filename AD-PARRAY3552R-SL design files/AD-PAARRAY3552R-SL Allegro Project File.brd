# Allegro board AD-PAARRAY3552R-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PGND: length 15.1
  TOP w0.508: 2.17,31.73 P5.G5 2.15,29.63 P5.G4 P5.G3 ; 2.17,31.73 P5.G6 ; 2.17,31.73 2.61,31.29 P5.G1 ; P5.G3 2.29,25.77 E1.1 2.31,23.43 R94.1 ; P5.G3 2.61,26.37 P5.G2
VCC_2992: length 7.1
  TOP w0.254: U23.7 16.26,13.44 C152.1
  TOP w0.508: C152.1 v1(17.17,13.57)
  BOTTOM w0.381: JP5.1 16.67,14.07 v1(17.17,13.57) 17.6,13.14 JP6.1
VCC_2992_1: length 7.1
  TOP w0.254: U30.7 50.29,13.44 C200.1
  TOP w0.508: C200.1 v1(51.21,13.57)
  BOTTOM w0.381: JP9.1 50.71,14.07 v1(51.21,13.57) 51.64,13.14 JP10.1
VCC_2992_2: length 7.1
  TOP w0.254: U31.7 33.27,13.44 C204.1
  TOP w0.508: C204.1 v1(34.19,13.57)
  BOTTOM w0.381: JP12.1 34.62,13.14 v1(34.19,13.57) 33.69,14.07 JP11.1
VCC_7000_1: length 53.2
  TOP w0.381: v1(81.53,29.13) v1(95.68,29.13)
  BOTTOM w0.305: U1.3 90.31,22.47 90.51,22.67
  BOTTOM w0.381: 90.51,22.67 91.25,23.41 C12.1 93.12,23.9 93.7,24.49 94.77,24.49 96.27,25.98 96.27,28.55 v1(95.68,29.13) ; v1(81.53,29.13) 81.51,29.11 R16.2 80.84,26.13 80.28,25.57 80.28,21.98 78.94,20.65 78.94,14.76 80.59,13.11 R174.1
VCC_7000_2: length 53.7
  TOP w0.381: v1(81.53,50.72) v1(95.68,50.72)
  BOTTOM w0.305: U2.3 90.31,44.06 90.51,44.26
  BOTTOM w0.381: v1(81.53,50.72) 81.51,50.7 R38.2 80.84,47.72 80.28,47.16 80.28,43.57 78.49,41.78 78.49,36.53 80.31,34.7 R30.1 ; v1(95.68,50.72) 96.27,50.14 96.27,47.57 94.77,46.08 93.7,46.08 93.12,45.49 C23.1 91.25,45 90.51,44.26
VCC_7000_3: length 53.2
  TOP w0.381: v1(59.94,29.13) v1(74.09,29.13)
  BOTTOM w0.305: 68.92,22.67 68.72,22.47 U25.3
  BOTTOM w0.381: R178.1 59,13.11 57.35,14.76 57.35,20.65 58.69,21.98 58.69,25.57 59.25,26.13 R127.2 59.92,29.11 v1(59.94,29.13) ; v1(74.09,29.13) 74.68,28.55 74.68,25.98 73.18,24.49 72.11,24.49 71.53,23.9 C166.1 69.66,23.41 68.92,22.67
32KIN_32666: length 6.2
  TOP w0.203: C122.1 40.62,27.38 Y2.1 38.36,27.38 36.2,29.54 U20.F1
32KOUT_32666: length 6.2
  TOP w0.102: U20.F2 35.01,29.87 35.61,29.87 35.72,29.97
  TOP w0.203: 35.72,29.97 38.71,29.97 Y2.2 40.62,29.87 C123.1
ADR0_2992: length 3.2
  TOP w0.203: U23.6 15.91,12.99 16.08,12.83 v1(16.81,12.83)
  BOTTOM w0.381: JP5.2 15.62,13.16 16.48,13.16 v1(16.81,12.83)
ADR0_2992_1: length 3.2
  TOP w0.203: U30.6 49.95,12.99 50.11,12.83 v1(50.85,12.83)
  BOTTOM w0.381: v1(50.85,12.83) 50.52,13.16 49.66,13.16 JP9.2
ADR0_2992_2: length 3.2
  TOP w0.203: U31.6 32.93,12.99 33.1,12.83 v1(33.83,12.83)
  BOTTOM w0.381: JP11.2 32.64,13.16 33.5,13.16 v1(33.83,12.83)
ADR1_2992: length 3.3
  TOP w0.203: U23.5 15.75,12.54 16.31,11.99 v1(16.81,11.99)
  BOTTOM w0.381: v1(16.81,11.99) 16.76,11.94 JP6.2
ADR1_2992_1: length 3.3
  TOP w0.203: U30.5 49.79,12.54 50.34,11.99 v1(50.85,11.99)
  BOTTOM w0.381: JP10.2 50.8,11.94 v1(50.85,11.99)
ADR1_2992_2: length 3.3
  TOP w0.203: U31.5 32.77,12.54 33.32,11.99 v1(33.83,11.99)
  BOTTOM w0.381: JP12.2 33.78,11.94 v1(33.83,11.99)
ALERT_N: length 3.5
  TOP w0.203: U12.11 51.73,51.88 52.7,50.9 52.7,50.55 53.26,49.99 R73.1
ALERT_N_1: length 3.5
  TOP w0.203: U16.11 35.12,51.88 36.09,50.9 36.09,50.55 36.65,49.99 R84.1
ALERT_N_2: length 3.5
  TOP w0.203: U26.11 18.5,51.88 19.48,50.9 19.48,50.55 20.04,49.99 R135.1
DAC_REF_3552R_0: length 18.2
  TOP w0.305: U12.20 v1(48.69,56.52)
  BOTTOM w0.305: v1(48.69,56.52) 47.85,56.52 46.28,54.94 46.28,49.63 46.76,49.15 46.76,47.27 45.77,46.28 43.69,46.28 43.34,45.93 C80.1 P3.2
DAC_REF_3552R_1: length 15
  TOP w0.305: U16.20 v1(32.08,56.52)
  BOTTOM w0.305: P4.2 29.68,45.92 C110.1 30.15,46.37 30.15,49.15 29.67,49.63 29.67,54.94 31.24,56.52 v1(32.08,56.52)
DAC_REF_3552R_2: length 15.1
  TOP w0.305: U26.20 v1(15.46,56.52)
  BOTTOM w0.305: v1(15.46,56.52) 14.63,56.52 13.13,55.02 13.13,49.53 12.88,49.28 12.47,49.28 12.17,48.97 12.17,47.52 12.57,47.12 C186.1 12.53,46.15 P11.2
DM_32666: length 13.9
  TOP w0.15: R96.2 14.2,29.69 v1(14.38,29.51) ; v1(19.3,28.42) 19.14,28.59 19.14,29.36 19.46,29.68 24.86,29.68 R205.2
  BOTTOM w0.15: v1(19.3,28.42) 19.13,28.6 19.13,28.98 18.76,29.35 17.43,29.35 17.31,29.48 U22.12 15.2,29.48 15.07,29.35 14.54,29.35 v1(14.38,29.51)
DP_32666: length 13.9
  TOP w0.15: R95.2 14.2,28.63 v1(14.38,28.8) ; v1(18.59,28.42) 18.76,28.59 18.76,29.51 19.3,30.06 24.86,30.06 R204.2
  BOTTOM w0.15: v1(14.38,28.8) 14.54,28.97 15.07,28.97 15.2,28.84 U22.11 17.31,28.84 17.43,28.97 18.6,28.97 18.75,28.82 18.75,28.58 v1(18.59,28.42)
HFXIN_32666: length 8.2
  TOP w0.203: U20.A4 33.38,25.56 32.44,24.61 32,24.61 30.91,23.52 30.91,22.71 31.66,21.96 Y1.1 32.53,20.57 C121.1
HFXOUT_32666: length 5.6
  TOP w0.102: U20.B4 33.38,26.94 33.71,26.62 33.71,26.01 33.86,25.86
  TOP w0.203: C124.1 35.74,23.26 Y1.3 34.23,25.49 33.86,25.86
IOUT0_3552R: length 7.5
  TOP w0.305: U12.26 43.33,53.88 v1(43.1,54.1) C71.2
  BOTTOM w0.305: A1.2 44.35,52.86 v1(43.1,54.1)
IOUT0_3552R_1: length 7.5
  TOP w0.305: U16.26 26.72,53.88 v1(26.49,54.1) C101.2
  BOTTOM w0.305: A3.2 27.74,52.86 v1(26.49,54.1)
IOUT0_3552R_2: length 7.5
  TOP w0.305: C177.2 v1(9.88,54.1) 10.1,53.88 U26.26
  BOTTOM w0.305: v1(9.88,54.1) 11.13,52.86 A5.2
IOUT1_3552R: length 6.3
  TOP w0.305: C73.2 v1(52.55,54.1) 52.33,53.88 U12.15
  BOTTOM w0.305: v1(52.55,54.1) 53.8,52.86 A2.2
IOUT1_3552R_1: length 6.3
  TOP w0.305: C103.2 v1(35.94,54.1) 35.72,53.88 U16.15
  BOTTOM w0.305: A4.2 37.19,52.86 v1(35.94,54.1)
IOUT1_3552R_2: length 6.3
  TOP w0.305: U26.15 19.11,53.88 v1(19.33,54.1) C179.2
  BOTTOM w0.305: A6.2 20.57,52.86 v1(19.33,54.1)
P0_0_UART2_CTS: length 19.5
  TOP w0.203: v1(20.75,37.97) 20.75,38.42 23.2,40.87 29.11,40.87 31.75,38.23 R181.1
  BOTTOM w0.203: v1(20.75,37.97) 20.73,37.95 20.73,37.64 21.67,36.7 23.52,36.7 24.49,35.74 P8.2
P0_1_UART2_TX: length 43.6
  TOP w0.203: v1(21.59,37.97) 21.59,38.43 23.57,40.41 28.63,40.41 30.68,38.35 R182.1 ; v1(10.97,37.59) 8.89,39.67 P6.6
  L3_SIG w0.203: v1(25.48,32.51) 25.48,33.12 23.57,35.03 12.7,35.03 10.97,36.75 v1(10.97,37.59)
  BOTTOM w0.203: P9.2 25.21,32.25 v1(25.48,32.51) 25.48,35.33 23.7,37.11 21.95,37.11 21.59,37.47 v1(21.59,37.97)
P0_2_UART2_RX: length 20.9
  TOP w0.203: v1(13,35.79) 11.91,35.79 9.3,38.4 P6.8 ; R192.1 22.89,34.44 v1(21.39,35.94)
  L3_SIG w0.203: v1(13,35.79) 21.23,35.79 v1(21.39,35.94)
  BOTTOM w0.203: P10.2 v1(13,35.79)
P0_3_UART2_RTS: length 1.2
  BOTTOM w0.203: P7.2 25.21,28.41 R206.2
P0_4_GPIO_FAULT: length 73.3
  TOP w0.203: R209.2 26.42,38.23 25.83,38.81 v1(25.12,38.81)
  L3_SIG w0.203: v1(71.36,6.56) 68.8,6.56 66.88,8.48 66.88,10.49 64.05,13.32 62.35,13.32 56.71,18.96 56.59,19.08 52.05,19.08 51.57,18.59 50.38,18.59 49.9,19.08 42.66,19.08 42.38,18.8 37.49,18.8 36.32,19.96 36.32,23.16 36.09,23.39 36.09,34.65 33.07,37.67 26.26,37.67 v1(25.12,38.81)
  BOTTOM w0.203: R236.2 v1(71.36,6.56)
P0_5_GPIO_FAULT: length 138.7
  TOP w0.203: v1(26.64,38.94) 26.65,38.94 26.72,38.94 27.48,38.18 R210.2
  L3_SIG w0.203: v1(93.68,31.52) 94.46,30.73 94.46,16.87 91.64,14.05 91.64,9.75 92.58,8.81 92.58,8.18 91.31,6.91 87.81,6.91 87.12,7.59 87.12,8.2 83.95,11.38 78.13,11.38 77.53,10.78 77.53,9 75.41,6.88 72.44,6.88 72.16,7.16 68.81,7.16 67.4,8.57 67.4,10.55 64.22,13.73 62.52,13.73 55.47,20.78 54.36,20.78 53.52,19.94 40.82,19.94 40.11,19.23 37.67,19.23 36.75,20.14 36.75,23.32 36.51,23.56 36.51,34.82 33.25,38.07 27.51,38.07 v1(26.64,38.94)
  BOTTOM w0.203: v1(93.68,31.52) 92.76,32.44 92.76,32.94 ; 92.76,32.94 92.76,32.95 ; 92.76,32.94 R40.1 92.76,32.95 ; 92.76,32.95 92.76,36.02 93.34,36.6 93.34,42.34 93.14,42.55 90.75,42.55 90.24,43.06 U2.5
P0_6_I2C0_SCL: length 99.4
  TOP w0.203: U23.9 11.2,13.89 v1(11.05,14.05) ; v1(19.28,37.72) 19.58,37.41 22.56,37.41 23.67,38.52 23.67,39.23 24.34,39.9 28.37,39.9 29.62,38.66 R211.2 ; v1(28.07,14.05) 28.22,13.89 U31.9 ; v1(45.09,14.05) 45.24,13.89 U30.9
  L3_SIG w0.203: v1(11.05,14.05) 6.02,14.05 5.13,14.94 5.13,19.05 6.25,20.17 v1(6.25,21.26)
  BOTTOM w0.203: v1(6.25,21.26) 10.12,25.14 10.12,35.52 12.37,37.77 17.75,37.77 18.31,38.33 19.08,38.33 19.28,38.13 v1(19.28,37.72) ; R105.1 10.9,14.2 v1(11.05,14.05) 11.76,14.76 11.76,15.65 12.65,16.54 17.27,16.54 18.16,17.42 25.86,17.42 27.36,15.93 27.36,14.76 v1(28.07,14.05) 28.78,14.76 28.78,15.65 29.67,16.54 34.29,16.54 35.18,17.42 42.88,17.42 44.37,15.93 44.37,14.76 v1(45.09,14.05)
P0_7_I2C0_SDA: length 104.2
  TOP w0.203: U31.10 28.33,13.44 v1(28.07,13.18) 28.26,12.99 U31.11 ; R212.2 28.55,38.81 27.86,39.5 24.51,39.5 24.08,39.07 24.08,38.35 22.73,37.01 19.02,37.01 18.54,37.49 v1(18.54,37.72) ; U23.10 11.31,13.44 v1(11.05,13.18) 11.24,12.99 U23.11 ; U30.11 45.27,12.99 v1(45.09,13.18) 45.35,13.44 U30.10
  L3_SIG w0.203: v1(11.05,13.18) 6.02,13.18 4.62,14.58 4.62,19.58 5.49,20.45 v1(5.49,20.7)
  BOTTOM w0.203: v1(45.09,13.18) 43.97,14.3 43.97,15.76 42.71,17.02 35.35,17.02 34.46,16.13 29.84,16.13 29.21,15.5 29.21,14.33 v1(28.07,13.18) 26.95,14.3 26.95,15.76 25.69,17.02 18.33,17.02 17.44,16.13 12.82,16.13 12.19,15.5 12.19,14.33 v1(11.05,13.18) 10.95,13.08 R108.1 ; v1(5.49,20.7) 6.5,20.7 10.59,24.79 10.59,35.33 12.62,37.36 18.19,37.36 v1(18.54,37.72)
P0_12_GPIO_LDAC0: length 32.8
  TOP w0.203: v1(39.37,41.5) 38.28,42.6 38.28,45.77 40.31,47.8 43.31,47.8 44.4,46.71 45.95,46.71 46.35,47.12 49.5,47.12 49.99,47.6 53.09,47.6 R71.2 52.94,48.26 52.3,48.26 51.82,48.74 51.82,50.52 51.46,50.88 U12.9
  BOTTOM w0.203: R185.1 40.64,40.23 v1(39.37,41.5)
P0_13_GPIO_LDAC1: length 18.3
  TOP w0.203: U16.9 34.85,50.88 35.2,50.52 35.2,48.74 36.09,47.85 R82.2 36.74,41.85 38,40.59 v1(38,40.03)
  BOTTOM w0.203: R186.1 39.57,38.46 v1(38,40.03)
P0_14_GPIO_FAULT_LED: length 58
  L3_SIG w0.203: v1(75.34,7.72) 75.06,8 73.84,8 73.43,7.59 68.99,7.59 67.84,8.74 67.84,10.68 64.39,14.14 62.69,14.14 55.64,21.18 54.19,21.18 53.35,20.35 40.65,20.35 40.12,19.81 v1(37.97,19.81)
  BOTTOM w0.203: v1(75.34,7.72) 76.05,8.43 78.16,8.43 79.63,6.96 R19.1 ; v1(37.97,19.81) 37.11,20.68 R187.1
P0_16_AIN0_MON: length 58.2
  TOP w0.203: v1(40.84,63.14) 40.84,63.22 40.47,63.59 R41.1 39.13,63.59 37.92,62.38 34.37,62.38 33.93,61.95 27.03,61.95 26.21,61.14 26.21,59.28 22.89,55.96 22.89,46.94 21.54,45.59 18.26,45.59 16.05,43.38 15.21,43.38 14.91,43.08 14.91,42.57 16.71,40.77 16.71,40.06 17.95,38.82 17.95,37.48 18.85,36.58 22.91,36.58 23.99,37.66 R188.1
  BOTTOM w0.203: R77.2 40.11,63.58 40.54,63.14 v1(40.84,63.14) 41.34,63.64 R78.1
P0_17_AIN1_MON: length 68.7
  TOP w0.203: v1(49.2,63.86) 49.2,63.8 49.28,63.73 R42.1
  L3_SIG w0.203: v1(20.14,40.13) 20.98,40.97 35.92,40.97 38.24,43.29 41.03,43.29 43.97,46.23 46.51,46.23 47.27,45.47 48.03,45.47 48.31,45.75 50.14,45.75 50.42,45.47 51.36,45.47 53.67,47.78 53.67,57.63 49.76,61.54 49.76,63.16 49.2,63.72 v1(49.2,63.86)
  BOTTOM w0.203: R189.1 28.45,39.4 28.02,39.83 20.45,39.83 v1(20.14,40.13) ; R80.1 51.08,63.72 R79.2 49.28,63.72 49.2,63.8 v1(49.2,63.86)
P0_18_AIN2_MON: length 48.1
  TOP w0.203: R68.1 v1(24.18,63.6)
  L3_SIG w0.203: v1(24.18,63.6) 23.57,63.6 19.05,59.08 15.93,59.08 14.43,57.58 13.56,57.58 10.46,54.48 10.46,52.17 10.19,51.89 10.19,45.24 13.16,42.27 13.16,41.4 15.6,38.96 v1(19.38,38.96)
  BOTTOM w0.203: R88.2 24.13,63.55 v1(24.18,63.6) 24.19,63.61 R89.1 ; v1(19.38,38.96) 19.51,38.84 23.7,38.84 24.57,37.97 R190.1
P0_19_AIN3_MON: length 52.9
  TOP w0.203: R191.1 21.49,33.35 17.53,37.31 17.53,38.58 16.31,39.8 16.31,40.56 14.5,42.37 14.5,43.26 15.04,43.79 15.82,43.79 18.03,46 21.34,46 22.48,47.14 22.48,56.36 25.76,59.64 25.76,61.29 26.82,62.36 33.22,62.36 33.48,62.62 v1(33.48,62.64) 33.52,62.68 33.52,62.84 33.49,62.87 R69.1
  BOTTOM w0.203: R91.1 33.64,63.67 R90.2 33.52,62.68 v1(33.48,62.64)
P0_20_AIN4_MON: length 48.2
  TOP w0.203: v1(7.65,64.72) 7.65,64.71 R130.1 ; v1(16.89,38.33) 16.89,37.36 22.58,31.67 R193.1
  L3_SIG w0.203: v1(16.89,38.33) 16.41,38.33 16.18,38.56 12.75,38.56 10.34,40.97 10.34,42.7 5.92,47.12 5.92,53.34 7.65,55.07 v1(7.65,64.72)
  BOTTOM w0.203: R139.2 v1(7.65,64.72)
  BOTTOM w0.305: R140.1 R139.2
P0_21_AIN5_MON: length 53.5
  TOP w0.203: R131.1 15.98,63.72 v1(15.98,63.73) ; v1(13.59,39.14) 13.59,39.04 14,38.63 14,37.26 15.88,35.38 15.88,26.95 v1(15.54,26.62)
  L3_SIG w0.203: v1(13.59,39.14) 13.11,39.14 12.24,40 12.24,42.02 6.98,47.28 6.98,48.36 8.66,50.04 8.66,55.5 10.43,57.26 10.43,59.83 14.14,63.54 15.79,63.54 v1(15.98,63.73)
  BOTTOM w0.203: v1(15.98,63.73) 16.08,63.62 R141.2 16.82,63.62 R142.1 ; R194.1 18.9,26.44 18.67,26.67 15.6,26.67 v1(15.54,26.62)
P0_22_AIN6_MON: length 25.7
  TOP w0.203: v1(14.15,41.88) 14.12,41.86 14.12,41.76 15.9,39.98 15.9,37.74 17.55,36.09 17.55,27.36 17.91,27 R195.1 ; R111.2 R110.1 17.27,43.74 v1(16.36,42.82)
  L3_SIG w0.203: v1(14.15,41.88) 15.42,41.88 v1(16.36,42.82)
P0_23_GPIO_LDAC2: length 35.6
  TOP w0.203: U26.9 18.23,50.88 18.59,50.52 18.59,48.74 19.48,47.85 R133.2 20.12,46.95 19.58,46.41 15.6,46.41 14.91,45.72 14.91,44.25 13.59,42.93 13.59,41.48 15.37,39.7 15.37,37.69 17.14,35.92 17.14,26.92 17.86,26.21 19.82,26.21 R196.1
P0_24_QSPI2_SS0: length 41.9
  TOP w0.203: U12.3 v1(47.69,48.77)
  L3_SIG w0.203: v1(47.69,48.77) 46.91,47.99 46.91,47.5 46.66,47.24 43.81,47.24 40.69,44.12 34.32,44.12 31.62,41.43 20.6,41.43 v1(19.28,40.11)
  BOTTOM w0.203: R197.1 26.29,38.46 25.37,39.37 20.02,39.37 v1(19.28,40.11)
P0_25_QSPI2_MOSI: length 81.2
  TOP w0.203: v1(32.72,47.88) 32.08,48.52 U16.5 ; U26.5 15.46,48.52 v1(16.1,47.88) ; v1(49.33,47.88) 48.69,48.52 U12.5
  L3_SIG w0.203: v1(49.33,47.88) 49.94,48.49 49.94,49.61 48.92,50.62 42.87,50.62 39.13,46.89 36.04,46.89 35.05,47.88 v1(32.72,47.88) 33.43,48.59 33.43,49.33 32.11,50.65 26.16,50.65 22.66,47.14 19.13,47.14 18.39,47.88 v1(16.1,47.88)
  BOTTOM w0.203: R198.1 30.58,38.94 28.75,40.77 21.03,40.77 20.62,41.17 13.89,41.17 13.56,41.5 13.56,43.08 14.43,43.94 14.43,46.91 13.89,47.45 13.89,49.02 14.25,49.38 14.86,49.38 15.16,49.07 15.16,48.29 15.57,47.88 v1(16.1,47.88)
P0_26_QSPI2_MISO: length 79.1
  TOP w0.203: v1(49.35,48.77) 49.19,48.93 U12.6 ; v1(16.13,48.77) 15.96,48.93 U26.6 ; v1(32.74,48.77) 32.58,48.93 U16.6
  L3_SIG w0.203: v1(16.13,48.77) 15.72,48.77 15.34,48.39 15.34,46.94 15.8,46.48 22.61,46.48 26.31,50.19 31.78,50.19 32.74,49.23 v1(32.74,48.77) 32,48.03 32,47.57 33.1,46.48 39.3,46.48 43.04,50.22 48.64,50.22 49.35,49.5 v1(49.35,48.77)
  BOTTOM w0.203: v1(16.13,48.77) 15.01,49.89 14.17,49.89 13.44,49.15 13.44,47.04 14,46.48 14,44.53 13.11,43.64 13.11,41.27 13.64,40.74 20.37,40.74 20.78,40.34 28.37,40.34 29.51,39.19 R199.1
P0_27_QSPI2_SCK: length 79.8
  TOP w0.203: U16.4 31.58,49.5 31.65,49.43 31.65,48.44 v1(31.09,47.88) ; v1(14.48,47.88) 15.04,48.44 15.04,49.43 14.96,49.5 U26.4 ; v1(47.7,47.88) 48.26,48.44 48.26,49.43 48.19,49.5 U12.4
  L3_SIG w0.203: v1(14.48,47.88) 14.73,47.62 14.73,45.19 15.04,44.88 22.07,44.88 26.7,49.5 31.29,49.5 31.75,49.05 31.75,48.54 v1(31.09,47.88) 31.09,47.07 32.74,45.42 39.34,45.42 43.41,49.48 47.98,49.48 48.36,49.1 48.36,48.54 v1(47.7,47.88)
  BOTTOM w0.203: R200.1 32.61,38.07 32.61,39.8 32.44,39.98 30.33,39.98 29.06,41.25 21.29,41.25 20.95,41.58 15.37,41.58 14.83,42.11 14.83,47.52 v1(14.48,47.88)
P0_28_GPIO_EN: length 48.6
  TOP w0.508: EN_SW.1 2.55,58.43 R167.1
  L3_SIG w0.203: v1(31.65,39.37) 31.01,40 21.69,40 20.02,38.33 18.24,38.33 17.53,37.62 16.41,37.62 15.93,38.1 12.62,38.1 9.91,40.82 9.91,42.52 5.49,46.94 5.49,55.47 EN_SW.1
  BOTTOM w0.203: R201.1 v1(31.65,39.37)
P0_30_QSPI2_SS1: length 17.5
  TOP w0.203: v1(27.43,42.27) 28.4,41.3 29.31,41.3 30.68,39.93 31.95,39.93 32.61,39.27 32.61,37.86 R207.2 ; U16.3 v1(31.08,48.77)
  L3_SIG w0.203: v1(27.43,42.27) 27.86,42.7 27.86,45.47 31.08,48.68 v1(31.08,48.77)
P0_31_QSPI2_SS2: length 30.4
  TOP w0.203: v1(14.46,48.77) U26.3 ; R208.2 33.88,38.86 32.31,40.44 30.84,40.44 29.49,41.78 28.7,41.78 27.89,42.6 27.89,43.21 v1(27.18,43.92)
  L3_SIG w0.203: v1(27.18,43.92) 27.18,44.45 26.92,44.7 25.88,44.7 25.37,44.2 14.78,44.2 14.02,44.96 14.02,45.95 13.69,46.28 13.69,48.06 14.4,48.77 v1(14.46,48.77)
P1_0_GPIO_FAULT: length 91.8
  TOP w0.203: v1(38.13,38.61) 38.15,38.58 R215.2
  L3_SIG w0.203: v1(91.01,8.53) 89.46,8.53 85.04,12.95 77.44,12.95 75.95,11.46 75.95,9.86 75.67,9.58 73.84,9.58 71.75,11.66 70.21,11.66 68.48,13.39 68.48,15.57 65.74,18.31 61.9,18.31 53.67,26.54 52.18,26.54 51.62,27.1 47.73,27.1 46.71,28.12 45.37,28.12 40.08,33.41 40.08,36.65 v1(38.13,38.61)
  BOTTOM w0.203: R18.1 v1(91.01,8.53) 91.59,9.12 91.59,13.26 93.34,15.01 93.34,20.75 93.14,20.95 90.75,20.95 90.24,21.47 U1.5
P1_1_GPIO_INP: length 58.3
  TOP w0.203: v1(37.06,38.63) 37.08,38.61 R216.2
  L3_SIG w0.203: v1(37.06,38.63) 39.67,36.02 39.67,33.24 45.21,27.71 46.53,27.71 47.55,26.7 51.45,26.7 52.01,26.14 53.5,26.14 61.73,17.91 65.57,17.91 68.07,15.4 68.07,13.22 70.04,11.25 71.35,11.25 v1(71.88,10.72)
  BOTTOM w0.203: R119.1 67.5,10.2 69.14,8.56 70.18,8.56 71.2,9.58 71.2,10.03 v1(71.88,10.72)
P1_2_GPIO_FAULT: length 66.6
  TOP w0.203: R223.2 35.05,37.76 v1(35.05,38.48)
  L3_SIG w0.203: v1(35.05,38.48) 39.27,34.26 39.27,33.07 46.05,26.29 51.29,26.29 51.84,25.73 53.33,25.73 61.56,17.5 65.4,17.5 67.67,15.23 67.67,13.05 69.87,10.85 70.89,10.85 v1(71.04,10.69)
  BOTTOM w0.203: U25.5 68.65,21.47 69.16,20.95 71.55,20.95 71.75,20.75 71.75,15.01 69.95,13.21 69.95,12.17 70.41,11.71 R129.1 71.03,10.71 v1(71.04,10.69)
P1_3_GPIO_EN: length 40.8
  TOP w0.203: R224.2 36.02,38.43 35.23,39.22 v1(35.08,39.22) ; v1(39.27,25.1) 39.24,25.12 37.85,25.12 37.34,24.61 37.34,19.2 36.93,18.8 25.59,18.8 R158.1
  L3_SIG w0.203: v1(35.08,39.22) 34.47,39.22 34.21,38.96 34.21,38.3 37.39,35.13 37.39,26.75 37.72,26.42 39.57,26.42 39.88,26.11 39.88,25.4 39.57,25.1 v1(39.27,25.1)
P1_4_GPIO_EN: length 52.1
  TOP w0.203: v1(39.24,25.86) 38,25.86 36.93,24.79 36.93,19.53 36.73,19.33 28.37,19.33 25.37,22.33 24.22,22.33 23.28,23.27 21.97,23.27 21.44,23.8 18.95,23.8 18.3,23.15 R157.1 18.11,22.5 17.91,22.3 U5.3
  L3_SIG w0.203: v1(39.24,25.86) 37.64,25.86 36.94,26.56 36.94,35 v1(33.2,38.73)
  BOTTOM w0.203: R225.2 33.73,37.54 33.5,37.77 33.5,38.43 v1(33.2,38.73)
P1_5_GPIO_EN: length 45.8
  TOP w0.203: U4.3 v1(65.53,53.19)
  L3_SIG w0.203: v1(40.16,42.34) 39.62,42.88 38.43,42.88 36.4,40.84 36.4,39.95 36.04,39.6 35.53,39.6 35.26,39.88 v1(33.78,39.88)
  BOTTOM w0.203: v1(65.53,53.19) 63.61,51.27 R155.1 63.61,49.74 60.45,46.58 54.46,46.58 53.24,45.36 50.55,45.36 50.16,45.75 48.41,45.75 45.69,43.03 40.84,43.03 v1(40.16,42.34) ; v1(33.78,39.88) 33.93,39.73 33.93,38 34.8,37.13 R226.2
P1_6_GPIO_RESET: length 87.8
  TOP w0.203: U12.10 51.64,51.38 52.25,50.77 52.25,49.23 v1(52.55,48.92) R72.2 ; U26.10 18.42,51.38 19.02,50.77 19.02,49.23 v1(19.33,48.92) R134.2 ; R83.2 v1(35.94,48.92) 35.64,49.23 35.64,50.77 35.03,51.38 U16.10
  L3_SIG w0.203: v1(52.55,48.92) 51.26,50.22 51.26,54.28 50.7,54.84 45.64,54.84 41.07,50.27 37.29,50.27 v1(35.94,48.92) 34.65,50.22 34.65,54.28 34.09,54.84 29.03,54.84 24.46,50.27 20.68,50.27 v1(19.33,48.92)
  BOTTOM w0.203: v1(19.33,48.92) 21.41,46.84 21.41,41.96 21.69,41.68 29.26,41.68 30.45,40.49 34.09,40.49 34.49,40.08 34.49,38.13 35.86,36.75 R227.2
P1_7_GPIO_IN: length 49.6
  TOP w0.203: v1(43.57,61.07) 43.61,61.11 R161.1
  L3_SIG w0.203: v1(43.57,61.07) 46.57,61.07 47.27,60.38 49.05,60.38 53.19,56.24 53.19,48.26 52.78,47.85 50.24,47.85 49.15,46.76 43.92,46.76 40.87,43.71 36.09,43.71 v1(35.18,42.8)
  BOTTOM w0.203: R228.2 36.93,37.24 35.92,38.25 35.92,39.27 35.18,40 v1(35.18,42.8) ; U14.6 43.77,61.27 v1(43.57,61.07)
P1_8_GPIO_INP: length 68.5
  L3_SIG w0.203: v1(87.02,10.16) 84.63,12.55 77.65,12.55 76.38,11.28 76.38,9.52 75.97,9.12 71.02,9.12 67.26,12.88 67.26,15.06 65.99,16.33 62.15,16.33 53.16,25.32 51.64,25.32 51.1,25.86 45.85,25.86 38.66,33.05 38.66,33.83 v1(38.71,33.88)
  BOTTOM w0.203: v1(38.71,33.88) 38.66,33.83 38.66,33.72 R229.2 ; v1(87.02,10.16) 87.02,10.26 87,10.29 87,10.85 88.16,12.01 R8.1
P1_9_GPIO_IN: length 42.4
  TOP w0.203: R162.1 53.06,61.11 v1(53.02,61.07) 51.79,59.84 46.58,59.84 45.34,58.6 42.19,58.6 39.98,56.39 39.98,48.08 37.85,45.95 37.85,42.16 39.7,40.31 39.7,33.25 39.5,33.05 R230.2
  BOTTOM w0.203: v1(53.02,61.07) 53.22,61.27 U15.6
P1_10_GPIO_IN: length 63.6
  TOP w0.203: R163.1 27,61.11 v1(26.96,61.07)
  L3_SIG w0.203: v1(26.96,61.07) 26.58,61.07 25.07,59.56 22.48,59.56 21.56,58.65 16.48,58.65 16.05,58.22 16.05,57.56 15.67,57.18 14.88,57.18 10.92,53.21 10.92,52.04 10.62,51.74 10.62,45.42 13.56,42.47 13.56,41.58 15.62,39.52 20.35,39.52 21.29,40.46 35.48,40.46 35.71,40.23 v1(35.79,40.23)
  BOTTOM w0.203: R217.2 38,36.78 36.32,38.46 36.32,39.62 35.79,40.16 v1(35.79,40.23) ; v1(26.96,61.07) 27.16,61.27 U18.6
P1_11_GPIO_IN: length 31.1
  TOP w0.203: R218.2 38.96,35.63 39.27,35.94 39.27,40.16 37.36,42.06 37.36,46.1 39.57,48.31 39.57,56.52 36.41,59.68 v1(36.41,61.07) 36.45,61.11 R164.1
  BOTTOM w0.203: U19.6 36.61,61.27 v1(36.41,61.07)
P1_12_GPIO_IN: length 48.2
  TOP w0.203: R219.2 19.18,25.73 17.5,25.73 16.74,26.49 16.74,35.7 14.96,37.48 14.96,39.42 13.41,40.97 12.06,40.97 v1(11.63,40.54) ; R165.1 10.39,61.11 v1(10.35,61.07)
  L3_SIG w0.203: v1(10.35,61.07) 10.33,61.07 8.17,58.92 8.17,54.98 6.32,53.14 6.32,47.36 11.66,42.03 11.66,40.56 v1(11.63,40.54)
  BOTTOM w0.203: U28.6 10.55,61.27 v1(10.35,61.07)
P1_13_GPIO_IN: length 52.6
  TOP w0.203: v1(19.8,61.07) 19.84,61.11 R166.1 ; v1(14.4,39.14) 14.4,37.43 16.31,35.53 16.31,26.21 v1(16.18,26.09)
  L3_SIG w0.203: v1(14.4,39.14) 14.4,39.55 12.75,41.2 12.75,42.09 7.98,46.86 7.98,47.55 9.12,48.69 9.12,54.43 11.35,56.67 11.35,57.94 13,59.59 18.41,59.59 19.8,60.97 v1(19.8,61.07)
  BOTTOM w0.203: v1(19.8,61.07) 19.99,61.27 U29.6 ; v1(16.18,26.09) 18.16,26.09 18.92,25.32 R220.2
QSPI_3552R: length 4.4
  TOP w0.203: U12.31 45.23,51.38 43.38,49.53 R70.2
QSPI_3552R_1: length 4.4
  TOP w0.203: R81.2 26.77,49.53 28.62,51.38 U16.31
QSPI_3552R_2: length 4.4
  TOP w0.203: R132.2 10.16,49.53 12.01,51.38 U26.31
RFB0_X1_3552R: length 2.3
  TOP w0.305: JP2.1 44.53,55.35 45.49,54.38 U12.25
RFB0_X1_3552R_1: length 2.3
  TOP w0.305: U16.25 28.88,54.38 27.91,55.35 JP4.1
RFB0_X1_3552R_2: length 2.3
  TOP w0.305: U26.25 12.27,54.38 11.3,55.35 JP8.1
RFB0_X2_3552R: length 3.2
  TOP w0.305: JP2.2 45.9,56.18 46.69,55.39 U12.24
RFB0_X2_3552R_1: length 3.2
  TOP w0.305: JP4.2 29.29,56.18 30.08,55.39 U16.24
RFB0_X2_3552R_2: length 3.2
  TOP w0.305: JP8.2 12.67,56.18 13.46,55.39 U26.24
RFB0_X4_3552R: length 13.3
  TOP w0.305: U12.23 47.19,55.63 45.8,57.02 JP2.3 ; JP2.3 43.03,57.02 41.33,55.33 C71.1 ; JP2.3 44.12,57.61 43.94,57.78 v1(43.08,57.78)
  BOTTOM w0.381: R75.1 v1(43.08,57.78) A1.6
RFB0_X4_3552R_1: length 13.3
  TOP w0.305: JP4.3 26.42,57.02 24.72,55.33 C101.1 ; JP4.3 29.18,57.02 30.58,55.63 U16.23 ; JP4.3 27.51,57.61 27.33,57.78 v1(26.47,57.78)
  BOTTOM w0.381: A3.6 v1(26.47,57.78) R86.1
RFB0_X4_3552R_2: length 13.3
  TOP w0.305: C177.1 8.11,55.33 9.8,57.02 JP8.3 ; JP8.3 10.9,57.61 10.72,57.78 v1(9.86,57.78) ; JP8.3 12.57,57.02 13.96,55.63 U26.23
  BOTTOM w0.381: A5.6 v1(9.86,57.78) R137.1
RFB1_X1_3552R: length 2.3
  TOP w0.305: U12.16 51.31,54.38 52.27,55.35 JP1.1
RFB1_X1_3552R_1: length 2.3
  TOP w0.305: U16.16 34.69,54.38 35.66,55.35 JP3.1
RFB1_X1_3552R_2: length 2.3
  TOP w0.305: U26.16 18.08,54.38 19.05,55.35 JP7.1
RFB1_X2_3552R: length 3.2
  TOP w0.305: JP1.2 50.98,56.18 50.19,55.4 50.19,55.08 U12.17
RFB1_X2_3552R_1: length 3.2
  TOP w0.305: U16.17 33.58,55.08 33.58,55.4 34.37,56.18 JP3.2
RFB1_X2_3552R_2: length 3.2
  TOP w0.305: U26.17 16.97,55.08 16.97,55.4 17.75,56.18 JP7.2
RFB1_X4_3552R: length 12
  TOP w0.305: JP1.3 50.95,57.02 49.69,55.76 U12.18 ; JP1.3 52.76,57.56 v1(52.53,57.78) ; JP1.3 53.85,57.02 54.32,56.55 C73.1
  BOTTOM w0.381: R76.1 v1(52.53,57.78) A2.6
RFB1_X4_3552R_1: length 12
  TOP w0.305: C103.1 37.71,56.55 37.24,57.02 JP3.3 ; JP3.3 36.14,57.56 v1(35.92,57.78) ; JP3.3 34.34,57.02 33.08,55.76 U16.18
  BOTTOM w0.381: A4.6 v1(35.92,57.78) R87.1
RFB1_X4_3552R_2: length 12
  TOP w0.305: C179.1 21.1,56.55 20.62,57.02 JP7.3 ; JP7.3 19.53,57.56 v1(19.3,57.78) ; JP7.3 17.73,57.02 16.46,55.76 U26.18
  BOTTOM w0.381: R138.1 v1(19.3,57.78) A6.6
RSTN_32666: length 109.4
  TOP w0.203: S3.3 v1(86.18,6.67) ; v1(9.75,36.83) 9.45,37.13 P6.10
  L3_SIG w0.203: v1(86.18,6.67) 86.18,8.53 84.1,10.62 78.33,10.62 77.98,10.26 77.98,8.84 75.62,6.48 72.8,6.48 72.24,5.92 68.86,5.92 66.47,8.31 66.47,10.31 63.88,12.9 62.18,12.9 56.41,18.67 52.22,18.67 51.74,18.19 50.22,18.19 49.73,18.67 42.82,18.67 42.55,18.39 37.29,18.39 v1(35.59,20.09) 35.36,19.86 30.45,19.86 28.78,21.54 23.93,21.54 21.67,23.8 19.05,23.8 18.75,24.1 18.75,26.09 17.6,27.23 17.6,27.81 12.6,32.82 11.96,32.82 9.75,35.03 v1(9.75,36.83)
  BOTTOM w0.203: v1(86.18,6.67) 86.2,6.65 R92.2 ; R180.1 36.4,22 36.4,20.9 v1(35.59,20.09)
SWDCLK_32666: length 26.2
  TOP w0.203: R173.1 8.62,40.94 v1(8.36,40.94) P6.4
  L3_SIG w0.203: v1(8.36,40.94) 8.76,40.94 12.32,37.39 15.54,37.39 16.18,36.75 21.97,36.75 24.74,39.52 27,39.52 v1(27.65,38.87)
  BOTTOM w0.203: R203.2 27.38,38.61 v1(27.65,38.87)
SWDIO_32666: length 27.4
  TOP w0.203: P6.2 v1(8.33,42.21) 8.33,42.94 R171.2
  L3_SIG w0.203: v1(8.33,42.21) 7.65,41.53 7.65,40.56 10.34,37.87 10.34,35.05 12.09,33.3 12.8,33.3 18.03,28.06 18.03,27.38 19.3,26.11 v1(19.3,24.38)
  BOTTOM w0.203: R202.2 19.46,24.21 19.3,24.36 v1(19.3,24.38)
UNNAMED_5_ADM7150_I112_BYP: length 1.4
  BOTTOM w0.305: C42.1 59.94,55.56 U9.3
UNNAMED_5_ADM7150_I112_REF: length 2.9
  BOTTOM w0.305: U9.6 59.94,50.58 60.28,50.24 60.44,50.24 ; 60.44,50.24 U9.5 ; 60.44,50.24 C51.1
UNNAMED_5_ADM7150_I112_VREG: length 1.7
  BOTTOM w0.305: C45.1 57.24,54.43 U9.1
UNNAMED_5_ADM7170_I67_SS: length 1.7
  TOP w0.305: U7.4 48.77,19.47 C46.1
UNNAMED_5_ADM7170_I73_SS: length 1.7
  TOP w0.305: C47.1 39.6,19.47 U8.4
UNNAMED_5_ADM7172_I160_EN: length 5.3
  TOP w0.203: U3.5 22.47,22.16 22.78,22.48 23.47,22.48 24.03,21.92 25.02,21.92 25.19,21.75 R159.1 25.19,20.19 R158.2
UNNAMED_5_ADM7172_I160_SS: length 1.7
  TOP w0.305: C30.1 24.06,18.67 U3.4
UNNAMED_5_ADMAX17643_I170_BST: length 1.7
  TOP w0.279: U6.10 73.81,44.18 C34.2
UNNAMED_5_ADMAX17643_I170_EN: length 3.1
  TOP w0.279: R47.2 74.92,50.25 74.31,49.65 U6.2
UNNAMED_5_ADMAX17643_I170_EXTVCC: length 5.5
  TOP w0.279: U6.9 73.31,44.71 v1(72.72,44.12)
  BOTTOM w0.381: v1(72.72,44.12) 72.55,43.95 C37.2 70.52,43.95 R52.2 70.45,43.94 R57.2
UNNAMED_5_ADMAX17643_I170_FB: length 3.5
  TOP w0.279: U6.7 72.31,45.49 71.62,44.79 R60.2
  TOP w0.305: R60.2 70.78,44.75 R59.1
UNNAMED_5_ADMAX17643_I170_LX: length 1.9
  TOP w0.279: U6.11 74.31,45.2 74.87,44.64 C34.1
UNNAMED_5_ADMAX17643_I170_RESETN: length 4
  TOP w0.279: U6.3 73.81,49.91 74.12,50.22 74.12,51.87 73.99,51.99 R48.2
UNNAMED_5_ADMAX17643_I170_RT: length 2
  TOP w0.279: U6.6 72.31,48.9 71.67,49.54 R49.2
UNNAMED_5_ADMAX17643_I170_SS: length 2.3
  TOP w0.279: U6.4 73.31,50.17 73.47,50.33 C28.1
UNNAMED_5_ADMAX17643_I170_VCC: length 5.4
  TOP w0.279: R48.1 C29.1 71.11,50.79 72.81,49.09 U6.5
UNNAMED_5_CAP_I20_N1: length 3.7
  TOP w0.305: R50.2 66.64,60.89 C32.1 66.64,60.22 66.03,59.61 U4.7
UNNAMED_5_CAP_I21_N1: length 3.7
  TOP w0.305: R51.2 9.19,23.41 C33.1 9.86,23.41 10.47,22.8 U5.7
UNNAMED_5_CAP_I88_N2: length 9.9
  TOP w0.254: v1(48.62,36.6) 48.73,36.49 U10.9
  TOP w0.381: R62.1 46.69,44.15 C43.2 v1(47.68,43.38)
  BOTTOM w0.381: v1(48.62,36.6) 47.68,37.54 v1(47.68,43.38)
UNNAMED_5_CAP_I90_N2: length 9.9
  TOP w0.254: v1(49.83,36.6) 49.73,36.49 U10.7
  TOP w0.381: v1(50.77,43.38) C48.2 51.77,44.15 R63.1
  BOTTOM w0.381: v1(50.77,43.38) 50.77,37.54 v1(49.83,36.6)
UNNAMED_5_CAP_I130_N2: length 5.2
  TOP w0.254: U10.4 49.73,32.27 50.85,31.14 R64.1
  TOP w0.381: R64.1 50.93,31.13 C57.2 52.4,29.6 R65.2
UNNAMED_5_CAP_I142_N1: length 4.6
  TOP w0.254: U10.3 49.23,31.15 R64.2 48.73,31.63 U10.2
  TOP w0.381: C55.1 49.2,31.13 R64.2
UNNAMED_5_CAP_I143_N1: length 4.8
  TOP w0.254: R67.2 48.23,31.58 U10.1
  TOP w0.381: R67.2 47.8,31.13 C56.1 46.33,29.6 R66.1
UNNAMED_5_DIOLED_I85_P: length 1.9
  TOP w0.381: DS3.A R61.1
UNNAMED_5_LINLT3042_I14_ILIM: length 1.5
  TOP w0.305: R45.2 67.98,54.54 U4.5
UNNAMED_5_LINLT3042_I14_PG: length 1.6
  TOP w0.203: U4.4 66.03,53.83 66.37,53.49 R43.1
UNNAMED_5_LINLT3042_I14_PGFB: length 2.4
  TOP w0.305: U4.6 67.99,58.75 R55.2 R53.1
UNNAMED_5_LINLT3042_I17_ILIM: length 1.5
  TOP w0.305: R46.2 15.54,24.75 U5.5
UNNAMED_5_LINLT3042_I17_PG: length 1.6
  TOP w0.203: R44.1 16.7,22.8 U5.4
UNNAMED_5_LINLT3042_I17_PGFB: length 2.4
  TOP w0.305: R54.1 R56.2 11.33,24.76 U5.6
UNNAMED_6_AD3552R_I19_CVREF: length 1.9
  TOP w0.305: U12.21 48.19,56.1 47.88,56.41 C65.2
UNNAMED_6_AD3552R_I19_NCAP0: length 4
  TOP w0.203: C63.2 43.31,52.07 44.12,52.88 U12.28
UNNAMED_6_AD3552R_I19_NCAP1: length 2.8
  TOP w0.203: C64.2 52.73,52.04 51.9,52.88 U12.13
UNNAMED_6_AD3552R_I19_PCAP0: length 4.2
  TOP w0.203: U12.29 44.48,52.38 43.15,51.05 C61.2
UNNAMED_6_AD3552R_I19_PCAP1: length 3
  TOP w0.203: C62.2 52.94,51.41 52.78,51.41 51.81,52.38 U12.12
UNNAMED_6_ADG1401_I69_D: length 7.2
  BOTTOM w0.305: R75.2 42.35,59.58 42.09,59.84 42.09,60.81 41.35,61.54 41.35,62.25 R78.2 42.77,62.64 C85.2 43.38,62.64 43.75,62.27 U14.8
UNNAMED_6_ADG1401_I72_D: length 7.3
  BOTTOM w0.305: R76.2 51.65,59.58 50.8,60.43 50.8,62.22 R80.2 51.2,62.62 C86.2 52.85,62.62 53.2,62.27 U15.8
UNNAMED_6_ADR45XX_I7_VOUT: length 3
  BOTTOM w0.305: R74.1 39.37,45.13 C75.1 39.33,44.09 U13.6
UNNAMED_6_NC2P_I13_N1: length 1.1
  BOTTOM w0.305: R74.2 P3.1
UNNAMED_7_AD3552R_I13_CVREF: length 1.9
  TOP w0.305: U16.21 31.58,56.1 31.27,56.41 C95.2
UNNAMED_7_AD3552R_I13_NCAP0: length 4
  TOP w0.203: C93.2 26.7,52.07 27.5,52.88 U16.28
UNNAMED_7_AD3552R_I13_NCAP1: length 2.8
  TOP w0.203: U16.13 35.28,52.88 36.12,52.04 C94.2
UNNAMED_7_AD3552R_I13_PCAP0: length 4.2
  TOP w0.203: C91.2 26.54,51.05 27.87,52.38 U16.29
UNNAMED_7_AD3552R_I13_PCAP1: length 3
  TOP w0.203: U16.12 35.2,52.38 36.17,51.41 36.33,51.41 C92.2
UNNAMED_7_ADG1401_I52_D: length 7.4
  BOTTOM w0.305: U19.8 36.59,62.27 36.21,62.64 C116.2 34.59,62.64 R91.2 34.19,62.29 34.19,60.43 35.03,59.58 R87.2
UNNAMED_7_ADG1401_I59_D: length 7.3
  BOTTOM w0.305: U18.8 27.14,62.27 26.69,62.72 C115.2 25.24,62.72 R89.2 24.74,62.22 24.74,61.54 25.48,60.81 25.48,59.84 25.74,59.58 R86.2
UNNAMED_7_ADR45XX_I83_VOUT: length 3
  BOTTOM w0.305: U17.6 25.61,44.91 C105.1 25.63,45.92 R85.1
UNNAMED_7_NC2P_I73_N1: length 1.1
  BOTTOM w0.305: R85.2 P4.1
UNNAMED_14_AD3552R_I75_CVREF: length 1.9
  TOP w0.305: U26.21 14.96,56.1 14.66,56.41 C171.2
UNNAMED_14_AD3552R_I75_NCAP0: length 4
  TOP w0.203: U26.28 10.89,52.88 10.08,52.07 C169.2
UNNAMED_14_AD3552R_I75_NCAP1: length 2.8
  TOP w0.203: C170.2 19.51,52.04 18.67,52.88 U26.13
UNNAMED_14_AD3552R_I75_PCAP0: length 4.2
  TOP w0.203: C167.2 9.93,51.05 11.26,52.38 U26.29
UNNAMED_14_AD3552R_I75_PCAP1: length 3
  TOP w0.203: C168.2 19.72,51.41 19.56,51.41 18.59,52.38 U26.12
UNNAMED_14_ADG1401_I59_D: length 7.4
  BOTTOM w0.305: R138.2 18.42,59.58 17.58,60.43 17.58,62.23 R142.2 18.07,62.72 C192.2 19.52,62.72 19.98,62.27 U29.8
UNNAMED_14_ADG1401_I68_D: length 7.5
  BOTTOM w0.305: R137.2 8.97,59.58 8.15,60.4 8.15,62.43 R140.2 9.55,62.72 C191.2 10.08,62.72 10.53,62.27 U28.8
UNNAMED_14_ADR45XX_I81_VOUT: length 3.2
  BOTTOM w0.305: U27.6 C181.1 7.61,46.15 R136.1
UNNAMED_14_NC2P_I28_N1: length 1.1
  BOTTOM w0.305: R136.2 P11.1
UNNAMED_16_ADLTC7000_I34_BST: length 5.1
  BOTTOM w0.305: U1.14 83.07,22.47 81.78,23.76 C9.1
  BOTTOM w0.381: C9.1 R16.1
UNNAMED_16_ADLTC7000_I34_IMON: length 2.6
  BOTTOM w0.203: U1.10 83.87,20.47 83.64,20.24 C11.1
UNNAMED_16_ADLTC7000_I34_INP: length 9.4
  BOTTOM w0.203: U1.7 89.9,20.47 90.09,20.28 R175.2 R174.2 R8.2
UNNAMED_16_ADLTC7000_I34_ISET: length 1.4
  BOTTOM w0.203: R12.1 84.72,18.82 U1.9
UNNAMED_16_ADLTC7000_I34_OVLO: length 3.5
  BOTTOM w0.305: U1.8 89.02,18.37 R4.1
  BOTTOM w0.508: R3.2 89.01,16.46 R4.1
UNNAMED_16_ADLTC7000_I34_RUN: length 9.1
  BOTTOM w0.203: U1.1 89.68,23.47 89.97,23.75 89.97,24.41 90.43,24.88 R172.1 R156.2
UNNAMED_16_ADLTC7000_I34_SNS: length 8.2
  BOTTOM w0.305: R10.2 85.99,27.11 85.14,26.26 C8.1 85.18,25.92 85.18,24.85 84.99,24.66 83.72,24.66 83.16,24.1 83.16,23.29 83.48,22.97 U1.15
UNNAMED_16_ADLTC7000_I34_SNS_1: length 9.6
  BOTTOM w0.305: U1.16 83.9,23.47 83.72,23.65 83.72,23.9 83.92,24.1 87.45,24.1 88.14,24.79 88.14,25.96 C8.2 88.14,26.29 87.31,27.11 R7.1
UNNAMED_16_ADLTC7000_I34_TGDN: length 2.9
  BOTTOM w0.203: R13.2 83.59,20.97 U1.11
UNNAMED_16_ADLTC7000_I34_TGUP: length 4.6
  BOTTOM w0.203: R11.2 81.78,20.68 82.7,20.68 83.49,21.47 U1.12
UNNAMED_16_ADLTC7000_I34_TIMER: length 13.6
  TOP w0.381: TP2.1 v1(90.98,9.93)
  BOTTOM w0.305: U1.6 90.08,20.97 90.93,20.12 C7.1 90.99,20.1 R6.1 90.99,15.88
  BOTTOM w0.381: 90.99,15.88 90.99,9.94 v1(90.98,9.93)
UNNAMED_16_ADLTC7000_I34_TS: length 11
  BOTTOM w0.305: C9.2 81.52,21.97 U1.13
  BOTTOM w0.508: C9.2 79.83,20.28 79.83,15.42 v1(80.24,15.01)
UNNAMED_16_ADLTC7000_I34_VCCUV: length 3.3
  BOTTOM w0.305: U1.4 90.7,21.97
  BOTTOM w0.381: 90.7,21.97 91.33,22.6 R5.1
UNNAMED_16_ADLTC7000_I34_VIN: length 12.5
  BOTTOM w0.305: U1.2 90,22.97 90.63,23.6 90.63,23.98 91.39,24.74 C3.1
  BOTTOM w0.381: R156.1 94.02,29.53 95.68,27.86 95.68,26.37 94.86,25.54 R2.1
  BOTTOM w0.508: C3.1 93.02,24.74 R2.1
UNNAMED_16_CAP_I47_N1: length 1
  BOTTOM w0.203: R14.1 82.74,15.93 C10.1
UNNAMED_16_DIOLED_I54_P: length 1.6
  TOP w0.381: R20.1 DS1.A
UNNAMED_16_RES_I38_N2: length 3.6
  TOP w0.508: v1(83.44,27.89) 83.44,25.32 R9.2
  BOTTOM w0.305: v1(83.44,27.89) R10.1
UNNAMED_16_RES_I60_N2: length 2
  TOP w0.381: R20.2 v1(78.18,7.38)
  BOTTOM w0.381: Q2.3 78.02,7.22 v1(78.18,7.38)
UNNAMED_16_RES_I76_N2: length 1.4
  BOTTOM w0.203: Q2.1 79.61,4.92 R19.2
UNNAMED_16_RES_I77_N2: length 5.2
  BOTTOM w0.203: R13.1 R11.1 80.85,16.82 R14.2 81.64,14.71 R15.1
UNNAMED_16_RES_I80_N2: length 3.2
  TOP w0.381: v1(84.89,15.7) 84.54,15.7 Q1.4
  BOTTOM w0.381: R15.2 84.35,14.71 84.89,15.24 v1(84.89,15.7)
UNNAMED_17_ADLTC7000_I28_BST: length 5.1
  BOTTOM w0.305: U2.14 83.07,44.06 81.78,45.35 C20.1
  BOTTOM w0.381: C20.1 R38.1
UNNAMED_17_ADLTC7000_I28_IMON: length 2.6
  BOTTOM w0.203: C22.1 83.64,41.83 83.87,42.06 U2.10
UNNAMED_17_ADLTC7000_I28_INP: length 8.3
  BOTTOM w0.203: R30.2 R176.2 90.09,41.87 89.9,42.06 U2.7
UNNAMED_17_ADLTC7000_I28_ISET: length 1.4
  BOTTOM w0.203: U2.9 84.72,40.41 R34.1
UNNAMED_17_ADLTC7000_I28_OVLO: length 3.5
  BOTTOM w0.305: R25.1 89.02,39.96 U2.8
  BOTTOM w0.508: R25.1 89.01,38.05 R24.2
UNNAMED_17_ADLTC7000_I28_RUN: length 9.1
  BOTTOM w0.203: R26.1 R23.1 90.43,46.47 89.97,46 89.97,45.34 89.68,45.06 U2.1
UNNAMED_17_ADLTC7000_I28_SNS: length 8.2
  BOTTOM w0.305: R32.2 85.99,48.7 85.14,47.85 C19.1 85.18,47.51 85.18,46.44 84.99,46.25 83.72,46.25 83.16,45.69 83.16,44.88 83.48,44.56 U2.15
UNNAMED_17_ADLTC7000_I28_SNS_1: length 9.6
  BOTTOM w0.305: R29.1 87.31,48.7 88.14,47.88 C19.2 88.14,47.55 88.14,46.38 87.45,45.69 83.92,45.69 83.72,45.49 83.72,45.24 83.9,45.06 U2.16
UNNAMED_17_ADLTC7000_I28_TGDN: length 2.9
  BOTTOM w0.203: U2.11 83.59,42.56 R35.2
UNNAMED_17_ADLTC7000_I28_TGUP: length 4.6
  BOTTOM w0.203: R33.2 81.78,42.27 82.7,42.27 83.49,43.06 U2.12
UNNAMED_17_ADLTC7000_I28_TIMER: length 13.6
  TOP w0.381: TP5.1 v1(90.98,31.52)
  BOTTOM w0.305: U2.6 90.08,42.56 90.93,41.71 C18.1 90.99,41.69 R28.1 90.99,37.47
  BOTTOM w0.381: 90.99,37.47 90.99,31.53 v1(90.98,31.52)
UNNAMED_17_ADLTC7000_I28_TS: length 11.7
  BOTTOM w0.305: C20.2 81.52,43.56 U2.13
  BOTTOM w0.508: v1(80.24,36.6) 79.71,36.6 79.38,36.93 79.38,41.42 C20.2
UNNAMED_17_ADLTC7000_I28_VCCUV: length 3.3
  BOTTOM w0.305: U2.4 90.7,43.56
  BOTTOM w0.381: 90.7,43.56 91.33,44.19 R27.1
UNNAMED_17_ADLTC7000_I28_VIN: length 12.5
  BOTTOM w0.305: U2.2 90,44.56 90.63,45.19 90.63,45.57 91.39,46.33 C17.1
  BOTTOM w0.381: R22.1 94.86,47.13 95.68,47.96 95.68,49.45 94.02,51.12 R26.2
  BOTTOM w0.508: C17.1 93.02,46.33 R22.1
UNNAMED_17_CAP_I41_N1: length 1.5
  BOTTOM w0.203: C21.1 82.78,37.52 R36.1
UNNAMED_17_RES_I37_N1: length 3.6
  TOP w0.508: v1(83.44,49.48) 83.44,46.91 R31.2
  BOTTOM w0.305: v1(83.44,49.48) R32.1
UNNAMED_17_RES_I39_N2: length 5.6
  BOTTOM w0.203: R37.2 81.52,36.33 81.05,36.8 81.05,37.19 80.43,37.81 R36.2 80.43,39.22 R33.1 R35.1
UNNAMED_17_RES_I40_N1: length 3.1
  TOP w0.381: v1(84.89,37.29) 84.54,37.29 Q3.4
  BOTTOM w0.381: v1(84.89,37.29) 83.82,36.22 R37.1
UNNAMED_18_ADLTC7000_I30_BST: length 5.1
  BOTTOM w0.305: U25.14 61.48,22.47 60.19,23.76 C163.1
  BOTTOM w0.381: C163.1 R127.1
UNNAMED_18_ADLTC7000_I30_IMON: length 2.6
  BOTTOM w0.203: C165.1 62.05,20.24 62.28,20.47 U25.10
UNNAMED_18_ADLTC7000_I30_INP: length 9.4
  BOTTOM w0.203: U25.7 68.31,20.47 68.5,20.28 R179.2 R178.2 R119.2
UNNAMED_18_ADLTC7000_I30_ISET: length 1.4
  BOTTOM w0.203: R123.1 63.13,18.82 U25.9
UNNAMED_18_ADLTC7000_I30_OVLO: length 3.5
  BOTTOM w0.305: U25.8 67.43,18.37 R115.1
  BOTTOM w0.508: R114.2 67.42,16.46 R115.1
UNNAMED_18_ADLTC7000_I30_RUN: length 9.1
  BOTTOM w0.203: U25.1 68.09,23.47 68.38,23.75 68.38,24.41 68.84,24.88 R160.1 R177.2
UNNAMED_18_ADLTC7000_I30_SNS: length 8.2
  BOTTOM w0.305: U25.15 61.89,22.97 61.57,23.29 61.57,24.1 62.13,24.66 63.4,24.66 63.59,24.85 63.59,25.92 C162.1 63.55,26.26 64.4,27.11 R121.2
UNNAMED_18_ADLTC7000_I30_SNS_1: length 9.6
  BOTTOM w0.305: R118.1 65.72,27.11 66.55,26.29 C162.2 66.55,25.96 66.55,24.79 65.86,24.1 62.33,24.1 62.13,23.9 62.13,23.65 62.31,23.47 U25.16
UNNAMED_18_ADLTC7000_I30_TGDN: length 2.9
  BOTTOM w0.203: R124.2 62,20.97 U25.11
UNNAMED_18_ADLTC7000_I30_TGUP: length 4.6
  BOTTOM w0.203: R122.2 60.19,20.68 61.11,20.68 61.9,21.47 U25.12
UNNAMED_18_ADLTC7000_I30_TIMER: length 13.6
  TOP w0.381: TP21.1 v1(69.39,9.93)
  BOTTOM w0.305: 69.4,15.88 R117.1 69.4,20.1 C161.1 69.34,20.12 68.49,20.97 U25.6
  BOTTOM w0.381: v1(69.39,9.93) 69.4,9.94 69.4,15.88
UNNAMED_18_ADLTC7000_I30_TS: length 11
  BOTTOM w0.305: C163.2 59.93,21.97 U25.13
  BOTTOM w0.508: v1(58.65,15.01) 58.24,15.42 58.24,20.28 C163.2
UNNAMED_18_ADLTC7000_I30_VCCUV: length 3.3
  BOTTOM w0.305: U25.4 69.11,21.97
  BOTTOM w0.381: R116.1 69.74,22.6 69.11,21.97
UNNAMED_18_ADLTC7000_I30_VIN: length 12.5
  BOTTOM w0.305: C160.1 69.8,24.74 69.04,23.98 69.04,23.6 68.41,22.97 U25.2
  BOTTOM w0.381: R113.1 73.27,25.54 74.09,26.37 74.09,27.86 72.43,29.53 R177.1
  BOTTOM w0.508: R113.1 71.43,24.74 C160.1
UNNAMED_18_CAP_I42_N1: length 1
  BOTTOM w0.203: R125.2 61.15,15.93 C164.1
UNNAMED_18_RES_I38_N1: length 3.6
  TOP w0.508: R120.2 61.85,25.32 v1(61.85,27.89)
  BOTTOM w0.305: v1(61.85,27.89) R121.1
UNNAMED_18_RES_I66_N1: length 5.2
  BOTTOM w0.203: R126.1 60.05,14.71 R125.1 59.26,16.82 R122.1 R124.1
UNNAMED_18_RES_I69_N2: length 3.2
  TOP w0.381: Q5.4 62.95,15.7 v1(63.3,15.7)
  BOTTOM w0.381: v1(63.3,15.7) 63.3,15.24 62.76,14.71 R126.2
UNNAMED_19_ADMAX32666_I33_DM: length 2.8
  TOP w0.15: R205.1 26.54,29.67 28.7,29.67 U20.F11
UNNAMED_19_ADMAX32666_I33_DP: length 2.8
  TOP w0.15: R204.1 26.55,30.06 28.7,30.06 U20.G11
UNNAMED_19_ADMAX32666_I33_LXA: length 3.6
  TOP w0.33: L6.2 28.51,26.62 U20.B11
UNNAMED_19_ADMAX32666_I33_LXB: length 5.5
  TOP w0.33: U20.A10 v2(29.16,25.97) 28.03,24.84 L6.1
  BOTTOM w0.305: v2(29.16,25.97) 29.04,25.97 28.68,25.61 C135.1
UNNAMED_19_ADMAX32666_I33_P0: length 3.5
  TOP w0.102: 28.07,31.72 28.3,31.49 U20.J11
  TOP w0.203: 28.07,31.72 26.44,33.35 R191.2
UNNAMED_19_ADMAX32666_I33_P0_1: length 11.9
  TOP w0.203: U20.E8 v2(30.46,28.57)
  L3_SIG w0.102: 28.93,26.29 29.59,26.29 30.13,26.83 30.13,27.54 30.46,27.86 v2(30.46,28.57)
  L3_SIG w0.203: v1(22.96,26.44) 23.32,26.8 27.53,26.8 28.04,26.29 28.93,26.29
  BOTTOM w0.203: R194.2 v1(22.96,26.44)
UNNAMED_19_ADMAX32666_I33_P0_2: length 7.8
  TOP w0.203: U20.H7 v2(31.11,31.17)
  BOTTOM w0.203: R200.2 32.72,36.32 32.61,36.22 31.8,36.22 31.01,35.43 31.01,33.15 31.5,32.66 31.5,31.56 v2(31.11,31.17)
UNNAMED_19_ADMAX32666_I33_P0_3: length 6.2
  TOP w0.203: U20.J7 v2(31.11,31.82)
  BOTTOM w0.203: R201.2 31.39,36.71 31.39,36.4 30.61,35.61 30.61,33.05 31.11,32.55 v2(31.11,31.82)
UNNAMED_19_ADMAX32666_I33_P0_4: length 9.7
  TOP w0.203: U20.G8 v2(30.46,29.87)
  BOTTOM w0.102: 28.65,31.29 29.44,30.51 29.81,30.51 v2(30.46,29.87)
  BOTTOM w0.203: R197.2 26.29,35.94 26.59,35.64 26.59,32.94 28.24,31.29 28.65,31.29
UNNAMED_19_ADMAX32666_I33_P0_7: length 13
  TOP w0.203: U20.G5 v2(33.06,30.52)
  BOTTOM w0.203: R185.2 40.64,31.09 40.11,30.56 39.01,30.56 37.82,29.36 33.68,29.36 33.06,29.99 v2(33.06,30.52)
UNNAMED_19_ADMAX32666_I33_P0_8: length 12.6
  TOP w0.203: U20.H5 v2(33.06,31.17)
  BOTTOM w0.203: v2(33.06,31.17) 33.5,30.72 33.5,30.15 33.88,29.77 37.64,29.77 38.84,30.96 39.85,30.96 40.21,31.32 40.21,33.53 39.57,34.16 R186.2
UNNAMED_19_ADMAX32666_I33_P0_9: length 5.8
  TOP w0.203: U20.F5 v2(33.06,29.22)
  BOTTOM w0.203: v2(33.06,29.22) 33.31,28.96 36.35,28.96 37.11,28.19 R187.2
UNNAMED_19_ADMAX32666_I33_P0_11: length 6.2
  TOP w0.203: U20.K11 27.51,33.46 27.51,34.11 26.29,35.33 25.93,35.33 25.35,35.92 R188.2
UNNAMED_19_ADMAX32666_I33_P0_12: length 9.9
  TOP w0.203: U20.G9 v2(29.81,29.87)
  BOTTOM w0.102: 28.37,30.86 28.63,30.86 29.29,30.2 29.47,30.2 v2(29.81,29.87)
  BOTTOM w0.203: 28.37,30.86 28.09,30.86 26.14,32.82 26.14,35.31 25.22,36.22 R190.2
UNNAMED_19_ADMAX32666_I33_P0_13: length 5
  TOP w0.102: U20.J10 29.16,31.82 28.56,31.82
  TOP w0.203: 28.56,31.82 27.1,33.27 27.1,33.93 26.59,34.44 R192.2
UNNAMED_19_ADMAX32666_I33_P0_14: length 3.6
  TOP w0.102: U20.H10 29.16,31.17 28.37,31.17
  TOP w0.203: 28.37,31.17 27.38,31.17 26.87,31.67 R193.2
UNNAMED_19_ADMAX32666_I33_P0_15: length 10.9
  TOP w0.203: R195.2 v1(21.95,27) ; U20.E9 v2(29.81,28.57)
  L3_SIG w0.102: v2(29.81,28.57) 29.48,28.24 29.48,27.09 29.33,26.94 28.97,26.94 28.8,26.77
  L3_SIG w0.203: v1(21.95,27) 22.15,27.2 27.71,27.2 28.24,26.67 28.7,26.67 28.8,26.77
UNNAMED_19_ADMAX32666_I33_P0_16: length 14.1
  TOP w0.203: R196.2 v1(21.95,25.88) ; U20.D8 v2(31.11,28.57)
  L3_SIG w0.102: 30.78,27.1 U20.D8 v2(31.11,28.57)
  L3_SIG w0.203: v1(21.95,25.88) 23.39,25.88 24.38,24.89 24.38,24.33 24.56,24.16 27.53,24.16 28.83,25.45 29.31,25.45 30.78,26.92 30.78,27.1
UNNAMED_19_ADMAX32666_I33_P0_17: length 6.8
  TOP w0.203: U20.H8 v2(30.46,31.17)
  BOTTOM w0.102: 30.61,32.46 30.78,32.29 30.78,31.49 v2(30.46,31.17)
  BOTTOM w0.203: R198.2 30.58,36.37 30.2,35.99 30.2,32.87 30.61,32.46
UNNAMED_19_ADMAX32666_I33_P0_18: length 6
  TOP w0.203: U20.J8 v2(30.46,31.82)
  BOTTOM w0.203: v2(30.46,31.82) 30.46,32.08 29.79,32.74 29.79,35.92 29.51,36.19 R199.2
UNNAMED_19_ADMAX32666_I33_P0_19: length 5.3
  TOP w0.102: 30.13,33.22 U20.L9
  TOP w0.203: 30.13,33.22 29.46,33.88 28.96,33.88 27.48,35.36 R210.1
UNNAMED_19_ADMAX32666_I33_P0_20: length 4.4
  TOP w0.102: U20.L8 30.78,33.74 30.61,33.91
  TOP w0.203: 30.61,33.91 29.69,34.82 29.69,36.58 R211.1
UNNAMED_19_ADMAX32666_I33_P0_21: length 6.4
  TOP w0.102: U20.K9 29.81,32.47 29.81,33.02 29.61,33.22
  TOP w0.203: 29.61,33.22 29.32,33.5 28.75,33.5 26.42,35.84 R209.1
UNNAMED_19_ADMAX32666_I33_P0_22: length 5.8
  TOP w0.102: U20.K8 30.46,32.47 30.46,33.48 30.3,33.63
  TOP w0.203: R212.1 28.5,36.61 28.5,34.92 29.03,34.39 29.54,34.39 30.3,33.63
UNNAMED_19_ADMAX32666_I33_P0_23: length 4.8
  TOP w0.102: 31.11,34 31.11,32.47 U20.K7
  TOP w0.203: 31.11,34 30.68,34.42 R182.2
UNNAMED_19_ADMAX32666_I33_P0_24: length 4.7
  TOP w0.102: 31.76,33.64 31.76,32.47 U20.K6
  TOP w0.203: R181.2 31.75,33.64 31.76,33.64
UNNAMED_19_ADMAX32666_I33_P0_25: length 5
  TOP w0.102: 33.06,34.17 33.06,32.47 U20.K5
  TOP w0.203: R208.1 33.88,35 33.06,34.17
UNNAMED_19_ADMAX32666_I33_P0_26: length 9
  TOP w0.203: U20.J9 v2(29.81,31.82)
  L3_SIG w0.203: v1(24.1,27.76) 24.49,27.76 28.54,31.82 v2(29.81,31.82)
  BOTTOM w0.203: v1(24.1,27.76) 24.55,27.31 R206.1
UNNAMED_19_ADMAX32666_I33_P0_27: length 5.5
  TOP w0.102: U20.J6 32.41,31.82 32.41,34.11 32.51,34.21
  TOP w0.203: 32.51,34.21 32.89,34.59 32.89,36.58 R207.1
UNNAMED_19_ADMAX32666_I33_P0_28: length 8.1
  TOP w0.203: U20.H9 v2(29.81,31.17)
  BOTTOM w0.203: v2(29.81,31.17) 29.81,31.23 28.65,32.38 28.4,32.38 27.41,33.38 27.41,35.59 27.64,35.81 28.02,35.81 28.45,36.25 R189.2
UNNAMED_19_ADMAX32666_I33_P1: length 4.5
  TOP w0.102: U20.L4 33.38,33.91 33.6,34.14
  TOP w0.203: 33.6,34.14 34.95,35.48 R223.1
UNNAMED_19_ADMAX32666_I33_P1_1: length 5.8
  TOP w0.102: 33.99,33.81 33.71,33.53 33.71,32.47 U20.K4
  TOP w0.203: 33.99,33.81 34.9,34.72 35.26,34.72 36.02,35.48 R224.1
UNNAMED_19_ADMAX32666_I33_P1_2: length 6
  TOP w0.102: U20.K3 34.36,32.47 34.36,33.47
  TOP w0.203: R216.1 37.08,35.89 34.95,33.76 34.65,33.76 34.36,33.47
UNNAMED_19_ADMAX32666_I33_P1_3: length 6.1
  TOP w0.102: 35.23,33.32 35.01,33.1 35.01,32.47 U20.K2
  TOP w0.203: 35.23,33.32 37.69,35.79 37.92,35.79 38.15,36.02 R215.1
UNNAMED_19_ADMAX32666_I33_P1_4: length 3.5
  TOP w0.203: U20.J5 v2(33.06,31.82)
  BOTTOM w0.203: v2(33.06,31.82) 33.06,32.47 33.45,32.87 33.45,33.48 33.73,33.76 R225.1
UNNAMED_19_ADMAX32666_I33_P1_5: length 3.6
  TOP w0.203: U20.J4 v2(33.71,31.82)
  BOTTOM w0.102: 34.36,33.44 34.36,32.98 33.71,32.33 v2(33.71,31.82)
  BOTTOM w0.203: R226.1 34.8,33.88 34.36,33.44
UNNAMED_19_ADMAX32666_I33_P1_6: length 3.8
  TOP w0.203: U20.J3 v2(34.36,31.82)
  BOTTOM w0.203: R227.1 35.86,34.47 35.2,33.81 35.2,33.22 34.36,32.37 v2(34.36,31.82)
UNNAMED_19_ADMAX32666_I33_P1_7: length 4.5
  TOP w0.203: U20.J2 v2(35.01,31.82)
  BOTTOM w0.203: v2(35.01,31.82) 35.01,32.49 35.59,33.07 35.59,33.5 35.81,33.73 36.7,33.73 36.93,33.96 R228.1
UNNAMED_19_ADMAX32666_I33_P1_8: length 7.7
  TOP w0.203: U20.H4 v2(33.71,31.17)
  BOTTOM w0.203: R229.1 39.06,31.45 38.73,31.45 37.64,30.35 35.51,30.35 35.31,30.15 34.11,30.15 33.96,30.3 33.96,30.91 v2(33.71,31.17)
UNNAMED_19_ADMAX32666_I33_P1_9: length 8.2
  TOP w0.203: U20.H3 v2(34.36,31.17)
  BOTTOM w0.203: v2(34.36,31.17) 34.63,30.89 37.59,30.89 38.66,31.95 38.66,32.97 38,33.63 R217.1
UNNAMED_19_ADMAX32666_I33_P1_10: length 6.1
  TOP w0.102: U20.H2 35.01,31.17 35.61,31.17
  TOP w0.203: R218.1 37.44,34.9 36.22,33.68 36.22,31.67 35.71,31.17 35.61,31.17
UNNAMED_19_ADMAX32666_I33_P1_11: length 3.8
  TOP w0.203: R230.1 36.73,31.82 36.73,31.42 36.09,30.78 35.39,30.78 U20.H1
UNNAMED_19_ADMAX32666_I33_P1_13: length 17.4
  TOP w0.203: U20.E6 v2(32.41,28.57)
  L3_SIG w0.203: v2(32.41,28.57) 31.94,28.57 31.65,28.27 31.65,27.18 30.48,26.01 30.48,24.56 28.75,22.83 24.56,22.83 23.98,23.42 23.98,24.71 23.37,25.32 v1(22.94,25.32)
  BOTTOM w0.203: R220.1 v1(22.94,25.32)
UNNAMED_19_ADMAX32666_I33_P1_14: length 18.2
  TOP w0.203: R219.1 v1(21.95,24.77) ; U20.E5 v2(33.06,28.57)
  L3_SIG w0.102: 32,28.09 32.15,28.24 32.73,28.24 v2(33.06,28.57)
  L3_SIG w0.203: v1(21.95,24.77) 23.29,24.77 23.57,24.49 23.57,23.19 24.33,22.43 28.93,22.43 30.89,24.38 30.89,25.83 32,26.95 32,28.09
UNNAMED_19_ADMAX32666_I33_RSTN: length 5.4
  TOP w0.203: U20.C5 v2(33.06,27.92)
  L3_SIG w0.203: v2(33.06,27.92) 33.6,27.37 33.6,26.47 v1(35.23,24.84)
  BOTTOM w0.203: R180.2 35.41,24.66 v1(35.23,24.84)
UNNAMED_19_ADMAX32666_I33_SWCLK: length 9.9
  TOP w0.203: U20.G7 v2(31.11,29.87)
  BOTTOM w0.102: v2(31.11,29.87) 30.16,30.81 29.69,30.81 28.75,31.75 28.63,31.75
  BOTTOM w0.203: 28.63,31.75 28.37,31.75 27,33.12 27,35.79 27.38,36.17 R203.1
UNNAMED_19_ADMAX32666_I33_SWDIO: length 17.6
  TOP w0.203: U20.C6 v2(32.41,27.92)
  L3_SIG w0.102: v2(32.41,27.92) 32.73,27.59 32.73,26.43 32.89,26.26
  L3_SIG w0.203: v1(22.96,24.21) 22.96,23.19 24.18,21.97 29.06,21.97 32.89,25.81 32.89,26.26
  BOTTOM w0.203: R202.1 v1(22.96,24.21)
UNNAMED_19_ADMAX32666_I33_VBST: length 1.4
  TOP w0.203: U20.C10 v2(29.16,27.27)
  BOTTOM w0.305: v2(29.16,27.27) 28.5,26.61 C135.2
UNNAMED_19_RES_I17_N1: length 2.7
  TOP w0.203: S3.1 81.33,2.67 R93.1
UNNAMED_20_ADMAX3207E_I10_I: length 10.4
  TOP w0.15: 8.09,29.34 5.93,29.34 5.79,29.48 P5.2 ; 8.09,29.34 U21.6 ; 8.09,29.34 9.99,29.34 ; 9.99,29.34 11.2,29.34 C145.1 11.76,29.35 12.24,29.35 R96.1 ; 9.99,29.34 U21.4
UNNAMED_20_ADMAX3207E_I10_I_1: length 10.3
  TOP w0.15: P5.3 5.79,28.83 5.93,28.96 8.09,28.96 ; 9.99,28.96 11.21,28.96 C144.1 11.76,28.97 12.24,28.97 R95.1 ; 9.99,28.96 U21.3 ; 9.99,28.96 8.09,28.96 ; U21.1 8.09,28.96
UNNAMED_20_ADMAX3207E_I10_VCC: length 8.7
  TOP w0.457: P5.1 6.56,30.13 6.96,30.53 C143.1 7.67,31.91 L7.1
  TOP w0.508: L7.1 9.04,32.75 U21.5
UNNAMED_20_CAP_I32_N1: length 2.9
  BOTTOM w0.254: C149.1 14.58,30.89 14.96,30.51 14.96,30.3 15.15,30.11 U22.13
UNNAMED_20_CAP_I35_N1: length 7.1
  TOP w0.508: v1(12.09,31.78) 12.09,32.91 L7.2
  BOTTOM w0.33: C147.1 14.05,31.93 14.59,31.38 U22.15
  BOTTOM w0.508: C147.1 C148.1 C146.1 12.09,32.47 v1(12.09,31.78)
UNNAMED_20_ICFT231XS_I38_CTS: length 2.9
  BOTTOM w0.203: P7.1 24.4,29.48 R97.2 23.26,29.48 U22.9
UNNAMED_20_ICFT231XS_I38_RTS: length 3.2
  BOTTOM w0.203: U22.2 22.86,33.92 R100.2 24.39,34.32 P8.1
UNNAMED_20_ICFT231XS_I38_RXD: length 3.5
  BOTTOM w0.203: U22.4 22.72,32.65 22.89,32.49 22.89,32.1 R98.2 24.39,31.72 P9.1
UNNAMED_20_ICFT231XS_I38_TXD: length 3
  BOTTOM w0.203: U22.20 14.48,34.56 R99.2 14.47,35.77 P10.1
UNNAMED_23_ADMAX6516_I1_HYST: length 4.9
  TOP w0.203: R146.2 R144.1 20.83,42.14 21.58,42.89 U24.3
UNNAMED_23_ADMAX6516_I1_OUT: length 1.5
  TOP w0.203: U24.1 20.35,44.79 R111.1
UNNAMED_23_ADMAX6516_I1_TOVER: length 71.7
  TOP w0.203: v1(37.21,40.06) 36.32,40.94 32.44,40.94 28.59,44.79 U24.5
  L3_SIG w0.203: v1(74.09,10.13) 73.86,10.13 71.91,12.09 70.36,12.09 68.88,13.56 68.88,15.75 65.91,18.72 62.08,18.72 56.85,23.95 56.85,25.37 54.46,27.76 51.69,27.76 51.46,27.53 47.88,27.53 46.89,28.52 45.54,28.52 40.49,33.58 40.49,37.08 38.25,39.32 37.46,39.32 37.21,39.57 v1(37.21,40.06)
  BOTTOM w0.203: v1(74.09,10.13) 72.87,10.13 72.6,9.86 Q4.1
UNNAMED_23_DIOLED_I12_N: length 3.5
  TOP w0.381: DS2.C v1(73.56,5.21)
  BOTTOM w0.381: R236.1 v1(73.56,5.21) Q4.3
UNNAMED_23_DIOLED_I12_P: length 2.1
  TOP w0.381: DS2.A v1(72.57,2.53)
  BOTTOM w0.381: v1(72.57,2.53) 72.56,2.54 R237.1
VCM0_3552R: length 6
  TOP w0.305: C72.2 v1(43.08,53.09) 43.37,53.38 U12.27
  BOTTOM w0.305: A1.3 v1(43.08,53.09)
VCM0_3552R_1: length 6
  TOP w0.305: C102.2 v1(26.47,53.09) 26.76,53.38 U16.27
  BOTTOM w0.305: A3.3 v1(26.47,53.09)
VCM0_3552R_2: length 6
  TOP w0.305: U26.27 10.15,53.38 v1(9.86,53.09) C178.2
  BOTTOM w0.305: A5.3 v1(9.86,53.09)
VCM1_3552R: length 4.8
  TOP w0.305: U12.14 52.23,53.38 v1(52.53,53.09) C74.2
  BOTTOM w0.305: A2.3 v1(52.53,53.09)
VCM1_3552R_1: length 4.8
  TOP w0.305: U16.14 35.62,53.38 v1(35.92,53.09) C104.2
  BOTTOM w0.305: A4.3 v1(35.92,53.09)
VCM1_3552R_2: length 4.8
  TOP w0.305: U26.14 19.01,53.38 v1(19.3,53.09) C180.2
  BOTTOM w0.305: A6.3 v1(19.3,53.09)
